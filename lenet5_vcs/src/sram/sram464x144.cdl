*
* Copyright (c) 1993 - 2022 ARM. All Rights Reserved
* This file has been provided pursuant to a License Agreement
* containing restrictions on its use.  This file contains valuable
* trade secrets and proprietary information of ARM,
* and is protected by patents, copyright law
* and international treaties
*
* Generated by bif2cdl 3.9.2
* Version: r1p1
* Name: High Density Single Port Register File RVT RVT Compiler | LOGIC0040LL 40nm Process 0.299um^2 Bit Cell
* Comment: This is a memory instance
* Configuration:  -activity_factor 50 -back_biasing off -bits 144 -\
* Configuration: bmux off -bus_notation on -check_instname on -diod\
* Configuration: es on -drive 6 -ema on -frequency 200 -instname sr\
* Configuration: am464x144 -left_bus_delim "[" -mux 2 -mvt "" -name\
* Configuration: _case upper -power_type otc -prefix "" -pwr_gnd_re\
* Configuration: name vddpe:VDDPE,vddce:VDDCE,vsse:VSSE -retention \
* Configuration: on -right_bus_delim "]" -ser none -site_def off -t\
* Configuration: op_layer m5-m10 -words 464 -write_mask off -write_\
* Configuration: thru off -corners ss_0p99v_0p99v_125c,tt_1p10v_1p1\
* Configuration: 0v_125c
* Codefile:
*
*
*.BIPOLAR
*.DIOAREA
*.DIOPERI
*
****
.SUBCKT sram464x144BOTCAP2X2 D0 D1 LOG0 Q0 Q1 TD0 TD1 TWEN0 TWEN1 VDDCE VDDPE
+  VNWP VPW VSS VSSE WEN0 WEN1 WENY0 WENY1
** sram464x144BOTCAP2X2: 8 flat devices **
DI13.D_Diode_X_dio VPW TD0 NDIO11LL AREA=0.035P PJ=0.78U
DI17.D_Diode_X_dio VPW D0 NDIO11LL AREA=0.035P PJ=0.78U
DI18.D_Diode_X_dio VPW TWEN0 NDIO11LL AREA=0.035P PJ=0.78U
DI19.D_Diode_X_dio VPW WEN0 NDIO11LL AREA=0.035P PJ=0.78U
DI77.D_Diode_X_dio VPW WEN1 NDIO11LL AREA=0.035P PJ=0.78U
DI78.D_Diode_X_dio VPW TWEN1 NDIO11LL AREA=0.035P PJ=0.78U
DI80.D_Diode_X_dio VPW D1 NDIO11LL AREA=0.035P PJ=0.78U
DI82.D_Diode_X_dio VPW TD1 NDIO11LL AREA=0.035P PJ=0.78U
.ENDS sram464x144BOTCAP2X2
****
.SUBCKT sram464x144BOTCAP2X2_RPT D0 D1 LOG0 Q0 Q1 VDDCE VNWP VPW WEN0 WEN1
+  WENY0 WENY1
** sram464x144BOTCAP2X2_RPT: 8 flat devices **
XI0 D0 D1 LOG0 Q0 Q1 LOG0 LOG0 LOG0 LOG0 VDDCE VNWP VNWP VPW VPW VPW WEN0 WEN1
+  WENY0 WENY1 sram464x144BOTCAP2X2
.ENDS sram464x144BOTCAP2X2_RPT
****
.SUBCKT sram464x144MIDBOT CA0 CA1 CA2 CEN CLK DUM_ACTP DUM_NACTC DUM_RETNVT
+  EMA0 EMA1 EMA2 EMAW0 EMAW1 GWEN LA0 LA1 LA2 LOG0 PGEN RA0 RA1 RA2 RA3 RA4
+  RA5 RDT RET1N RET2N VDDCE VDDC_L VDDC_R VDDPE VDDP_CLKGEN VNWC VNWP VPW VSS
+  VSSE
** sram464x144MIDBOT: 24 flat devices **
DI103.D_Diode_X_dio VPW CLK NDIO11LL AREA=0.035P PJ=0.78U
DI104.D_Diode_X_dio VPW EMAW0 NDIO11LL AREA=0.035P PJ=0.78U
DI105.D_Diode_X_dio VPW EMA2 NDIO11LL AREA=0.035P PJ=0.78U
DI106.D_Diode_X_dio VPW RDT NDIO11LL AREA=0.035P PJ=0.78U
DI107.D_Diode_X_dio VPW RET1N NDIO11LL AREA=0.035P PJ=0.78U
DI109.D_Diode_X_dio VPW EMA0 NDIO11LL AREA=0.035P PJ=0.78U
DI110.D_Diode_X_dio VPW GWEN NDIO11LL AREA=0.035P PJ=0.78U
DI111.D_Diode_X_dio VPW EMAW1 NDIO11LL AREA=0.035P PJ=0.78U
DI112.D_Diode_X_dio VPW EMA1 NDIO11LL AREA=0.035P PJ=0.78U
DI113.D_Diode_X_dio VPW CEN NDIO11LL AREA=0.035P PJ=0.78U
DI125.D_Diode_X_dio VPW PGEN NDIO11LL AREA=0.035P PJ=0.78U
DI127.D_Diode_X_dio VPW RET2N NDIO11LL AREA=0.035P PJ=0.78U
DI59.D_Diode_X_dio VPW CA0 NDIO11LL AREA=0.035P PJ=0.78U
DI61.D_Diode_X_dio VPW CA1 NDIO11LL AREA=0.035P PJ=0.78U
DI62.D_Diode_X_dio VPW LA0 NDIO11LL AREA=0.035P PJ=0.78U
DI63.D_Diode_X_dio VPW CA2 NDIO11LL AREA=0.035P PJ=0.78U
DI64.D_Diode_X_dio VPW RA2 NDIO11LL AREA=0.035P PJ=0.78U
DI67.D_Diode_X_dio VPW RA3 NDIO11LL AREA=0.035P PJ=0.78U
DI68.D_Diode_X_dio VPW RA1 NDIO11LL AREA=0.035P PJ=0.78U
DI69.D_Diode_X_dio VPW RA0 NDIO11LL AREA=0.035P PJ=0.78U
DI70.D_Diode_X_dio VPW RA4 NDIO11LL AREA=0.035P PJ=0.78U
DI71.D_Diode_X_dio VPW RA5 NDIO11LL AREA=0.035P PJ=0.78U
DI72.D_Diode_X_dio VPW LA1 NDIO11LL AREA=0.035P PJ=0.78U
DI73.D_Diode_X_dio VPW LA2 NDIO11LL AREA=0.035P PJ=0.78U
.ENDS sram464x144MIDBOT
****
.SUBCKT sram464x144MIDBOT_WRAPT CA0 CA1 CA2 CEN CLK DUM_ACTP DUM_NACTC
+  DUM_RETNVT EMA0 EMA1 EMA2 EMAW0 EMAW1 GWEN LA0 LA1 LA2 LOG0 RA0 RA1 RA2 RA3
+  RA4 RA5 RDT RET1N VDDCE VDDC_L VDDC_R VDDPE VDDP_CLKGEN VNWC VNWP VPW VSS
+  VSSE
** sram464x144MIDBOT_WRAPT: 24 flat devices **
XI0 CA0 CA1 CA2 CEN CLK DUM_ACTP DUM_NACTC DUM_RETNVT EMA0 EMA1 EMA2 EMAW0
+  EMAW1 GWEN LA0 LA1 LA2 LOG0 PGEN RA0 RA1 RA2 RA3 RA4 RA5 RDT RET1N RET2N
+  VDDCE VDDC_L VDDC_R VDDPE VDDP_CLKGEN VNWC VNWP VPW VSS VSSE
+  sram464x144MIDBOT
.ENDS sram464x144MIDBOT_WRAPT
****
.SUBCKT sram464x144BOTCORNER LOG0 PSI SI VNWC VNWP VPW VSS
** sram464x144BOTCORNER: 2 flat devices **
DI74.D_Diode_X_dio VPW PSI NDIO11LL AREA=0.035P PJ=0.78U
DI85.D_Diode_X_dio VPW SI NDIO11LL AREA=0.035P PJ=0.78U
.ENDS sram464x144BOTCORNER
****
.SUBCKT sram464x144BOTCORNER_WRAPT LOG0 PSI SI VNWC VNWP VPW VSS
** sram464x144BOTCORNER_WRAPT: 2 flat devices **
XI0 LOG0 PSI SI VNWC VNWP VPW VSS sram464x144BOTCORNER
.ENDS sram464x144BOTCORNER_WRAPT
****
.SUBCKT sram464x144BOTCAPROW CA0 CA1 CA2 CEN CLK D0_0 D0_1 D0_2 D0_3 D0_4 D0_5
+  D0_6 D0_7 D0_8 D0_9 D0_10 D0_11 D0_12 D0_13 D0_14 D0_15 D0_16 D0_17 D0_18
+  D0_19 D0_20 D0_21 D0_22 D0_23 D0_24 D0_25 D0_26 D0_27 D0_28 D0_29 D0_30
+  D0_31 D0_32 D0_33 D0_34 D0_35 D0_36 D0_37 D0_38 D0_39 D0_40 D0_41 D0_42
+  D0_43 D0_44 D0_45 D0_46 D0_47 D0_48 D0_49 D0_50 D0_51 D0_52 D0_53 D0_54
+  D0_55 D0_56 D0_57 D0_58 D0_59 D0_60 D0_61 D0_62 D0_63 D0_64 D0_65 D0_66
+  D0_67 D0_68 D0_69 D0_70 D0_71 D1_0 D1_1 D1_2 D1_3 D1_4 D1_5 D1_6 D1_7 D1_8
+  D1_9 D1_10 D1_11 D1_12 D1_13 D1_14 D1_15 D1_16 D1_17 D1_18 D1_19 D1_20
+  D1_21 D1_22 D1_23 D1_24 D1_25 D1_26 D1_27 D1_28 D1_29 D1_30 D1_31 D1_32
+  D1_33 D1_34 D1_35 D1_36 D1_37 D1_38 D1_39 D1_40 D1_41 D1_42 D1_43 D1_44
+  D1_45 D1_46 D1_47 D1_48 D1_49 D1_50 D1_51 D1_52 D1_53 D1_54 D1_55 D1_56
+  D1_57 D1_58 D1_59 D1_60 D1_61 D1_62 D1_63 D1_64 D1_65 D1_66 D1_67 D1_68
+  D1_69 D1_70 D1_71 DUM_ACTP DUM_NACTC DUM_RETNVT EMA0 EMA1 EMA2 EMAW0 EMAW1
+  GWEN LA0 LA1 LA2 LOG0 PSI_0 PSI_1 Q0_0 Q0_1 Q0_2 Q0_3 Q0_4 Q0_5 Q0_6 Q0_7
+  Q0_8 Q0_9 Q0_10 Q0_11 Q0_12 Q0_13 Q0_14 Q0_15 Q0_16 Q0_17 Q0_18 Q0_19 Q0_20
+  Q0_21 Q0_22 Q0_23 Q0_24 Q0_25 Q0_26 Q0_27 Q0_28 Q0_29 Q0_30 Q0_31 Q0_32
+  Q0_33 Q0_34 Q0_35 Q0_36 Q0_37 Q0_38 Q0_39 Q0_40 Q0_41 Q0_42 Q0_43 Q0_44
+  Q0_45 Q0_46 Q0_47 Q0_48 Q0_49 Q0_50 Q0_51 Q0_52 Q0_53 Q0_54 Q0_55 Q0_56
+  Q0_57 Q0_58 Q0_59 Q0_60 Q0_61 Q0_62 Q0_63 Q0_64 Q0_65 Q0_66 Q0_67 Q0_68
+  Q0_69 Q0_70 Q0_71 Q1_0 Q1_1 Q1_2 Q1_3 Q1_4 Q1_5 Q1_6 Q1_7 Q1_8 Q1_9 Q1_10
+  Q1_11 Q1_12 Q1_13 Q1_14 Q1_15 Q1_16 Q1_17 Q1_18 Q1_19 Q1_20 Q1_21 Q1_22
+  Q1_23 Q1_24 Q1_25 Q1_26 Q1_27 Q1_28 Q1_29 Q1_30 Q1_31 Q1_32 Q1_33 Q1_34
+  Q1_35 Q1_36 Q1_37 Q1_38 Q1_39 Q1_40 Q1_41 Q1_42 Q1_43 Q1_44 Q1_45 Q1_46
+  Q1_47 Q1_48 Q1_49 Q1_50 Q1_51 Q1_52 Q1_53 Q1_54 Q1_55 Q1_56 Q1_57 Q1_58
+  Q1_59 Q1_60 Q1_61 Q1_62 Q1_63 Q1_64 Q1_65 Q1_66 Q1_67 Q1_68 Q1_69 Q1_70
+  Q1_71 RA0 RA1 RA2 RA3 RA4 RA5 RDT RET1N SI_0 SI_1 VDDCE_0 VDDCE_1 VDDCE_2
+  VDDCE_3 VDDCE_4 VDDCE_5 VDDCE_6 VDDCE_7 VDDCE_8 VDDCE_9 VDDCE_10 VDDCE_11
+  VDDCE_12 VDDCE_13 VDDCE_14 VDDCE_15 VDDCE_16 VDDCE_17 VDDCE_18 VDDCE_19
+  VDDCE_20 VDDCE_21 VDDCE_22 VDDCE_23 VDDCE_24 VDDCE_25 VDDCE_26 VDDCE_27
+  VDDCE_28 VDDCE_29 VDDCE_30 VDDCE_31 VDDCE_32 VDDCE_33 VDDCE_34 VDDCE_35
+  VDDCE_36 VDDCE_37 VDDCE_38 VDDCE_39 VDDCE_40 VDDCE_41 VDDCE_42 VDDCE_43
+  VDDCE_44 VDDCE_45 VDDCE_46 VDDCE_47 VDDCE_48 VDDCE_49 VDDCE_50 VDDCE_51
+  VDDCE_52 VDDCE_53 VDDCE_54 VDDCE_55 VDDCE_56 VDDCE_57 VDDCE_58 VDDCE_59
+  VDDCE_60 VDDCE_61 VDDCE_62 VDDCE_63 VDDCE_64 VDDCE_65 VDDCE_66 VDDCE_67
+  VDDCE_68 VDDCE_69 VDDCE_70 VDDCE_71 VDDCE_72 VDDC_L VDDC_R VDDPE
+  VDDP_CLKGEN VNWC_0 VNWC_1 VNWC_2 VNWP VPW VSSE WEN0_0 WEN0_1 WEN0_2 WEN0_3
+  WEN0_4 WEN0_5 WEN0_6 WEN0_7 WEN0_8 WEN0_9 WEN0_10 WEN0_11 WEN0_12 WEN0_13
+  WEN0_14 WEN0_15 WEN0_16 WEN0_17 WEN0_18 WEN0_19 WEN0_20 WEN0_21 WEN0_22
+  WEN0_23 WEN0_24 WEN0_25 WEN0_26 WEN0_27 WEN0_28 WEN0_29 WEN0_30 WEN0_31
+  WEN0_32 WEN0_33 WEN0_34 WEN0_35 WEN0_36 WEN0_37 WEN0_38 WEN0_39 WEN0_40
+  WEN0_41 WEN0_42 WEN0_43 WEN0_44 WEN0_45 WEN0_46 WEN0_47 WEN0_48 WEN0_49
+  WEN0_50 WEN0_51 WEN0_52 WEN0_53 WEN0_54 WEN0_55 WEN0_56 WEN0_57 WEN0_58
+  WEN0_59 WEN0_60 WEN0_61 WEN0_62 WEN0_63 WEN0_64 WEN0_65 WEN0_66 WEN0_67
+  WEN0_68 WEN0_69 WEN0_70 WEN0_71 WEN1_0 WEN1_1 WEN1_2 WEN1_3 WEN1_4 WEN1_5
+  WEN1_6 WEN1_7 WEN1_8 WEN1_9 WEN1_10 WEN1_11 WEN1_12 WEN1_13 WEN1_14 WEN1_15
+  WEN1_16 WEN1_17 WEN1_18 WEN1_19 WEN1_20 WEN1_21 WEN1_22 WEN1_23 WEN1_24
+  WEN1_25 WEN1_26 WEN1_27 WEN1_28 WEN1_29 WEN1_30 WEN1_31 WEN1_32 WEN1_33
+  WEN1_34 WEN1_35 WEN1_36 WEN1_37 WEN1_38 WEN1_39 WEN1_40 WEN1_41 WEN1_42
+  WEN1_43 WEN1_44 WEN1_45 WEN1_46 WEN1_47 WEN1_48 WEN1_49 WEN1_50 WEN1_51
+  WEN1_52 WEN1_53 WEN1_54 WEN1_55 WEN1_56 WEN1_57 WEN1_58 WEN1_59 WEN1_60
+  WEN1_61 WEN1_62 WEN1_63 WEN1_64 WEN1_65 WEN1_66 WEN1_67 WEN1_68 WEN1_69
+  WEN1_70 WEN1_71 WENY0_0 WENY0_1 WENY0_2 WENY0_3 WENY0_4 WENY0_5 WENY0_6
+  WENY0_7 WENY0_8 WENY0_9 WENY0_10 WENY0_11 WENY0_12 WENY0_13 WENY0_14
+  WENY0_15 WENY0_16 WENY0_17 WENY0_18 WENY0_19 WENY0_20 WENY0_21 WENY0_22
+  WENY0_23 WENY0_24 WENY0_25 WENY0_26 WENY0_27 WENY0_28 WENY0_29 WENY0_30
+  WENY0_31 WENY0_32 WENY0_33 WENY0_34 WENY0_35 WENY0_36 WENY0_37 WENY0_38
+  WENY0_39 WENY0_40 WENY0_41 WENY0_42 WENY0_43 WENY0_44 WENY0_45 WENY0_46
+  WENY0_47 WENY0_48 WENY0_49 WENY0_50 WENY0_51 WENY0_52 WENY0_53 WENY0_54
+  WENY0_55 WENY0_56 WENY0_57 WENY0_58 WENY0_59 WENY0_60 WENY0_61 WENY0_62
+  WENY0_63 WENY0_64 WENY0_65 WENY0_66 WENY0_67 WENY0_68 WENY0_69 WENY0_70
+  WENY0_71 WENY1_0 WENY1_1 WENY1_2 WENY1_3 WENY1_4 WENY1_5 WENY1_6 WENY1_7
+  WENY1_8 WENY1_9 WENY1_10 WENY1_11 WENY1_12 WENY1_13 WENY1_14 WENY1_15
+  WENY1_16 WENY1_17 WENY1_18 WENY1_19 WENY1_20 WENY1_21 WENY1_22 WENY1_23
+  WENY1_24 WENY1_25 WENY1_26 WENY1_27 WENY1_28 WENY1_29 WENY1_30 WENY1_31
+  WENY1_32 WENY1_33 WENY1_34 WENY1_35 WENY1_36 WENY1_37 WENY1_38 WENY1_39
+  WENY1_40 WENY1_41 WENY1_42 WENY1_43 WENY1_44 WENY1_45 WENY1_46 WENY1_47
+  WENY1_48 WENY1_49 WENY1_50 WENY1_51 WENY1_52 WENY1_53 WENY1_54 WENY1_55
+  WENY1_56 WENY1_57 WENY1_58 WENY1_59 WENY1_60 WENY1_61 WENY1_62 WENY1_63
+  WENY1_64 WENY1_65 WENY1_66 WENY1_67 WENY1_68 WENY1_69 WENY1_70 WENY1_71
** sram464x144BOTCAPROW: 604 flat devices **
XCENTRE CA0 CA1 CA2 CEN CLK DUM_ACTP DUM_NACTC DUM_RETNVT EMA0 EMA1 EMA2 EMAW0
+  EMAW1 GWEN LA0 LA1 LA2 LOG0 RA0 RA1 RA2 RA3 RA4 RA5 RDT RET1N VDDCE_36
+  VDDC_L VDDC_R VDDPE VDDP_CLKGEN VNWC_1 VNWP VPW VPW VSSE
+  sram464x144MIDBOT_WRAPT
XLEFT LOG0 PSI_0 SI_0 VNWC_0 VNWP VPW VPW sram464x144BOTCORNER_WRAPT
XLEFT_COL_0 D0_0 D1_0 LOG0 Q0_0 Q1_0 VDDCE_0 VNWP VPW WEN0_0 WEN1_0 WENY0_0
+  WENY1_0 sram464x144BOTCAP2X2_RPT
XLEFT_COL_1 D0_1 D1_1 LOG0 Q0_1 Q1_1 VDDCE_1 VNWP VPW WEN0_1 WEN1_1 WENY0_1
+  WENY1_1 sram464x144BOTCAP2X2_RPT
XLEFT_COL_10 D0_10 D1_10 LOG0 Q0_10 Q1_10 VDDCE_10 VNWP VPW WEN0_10 WEN1_10
+  WENY0_10 WENY1_10 sram464x144BOTCAP2X2_RPT
XLEFT_COL_11 D0_11 D1_11 LOG0 Q0_11 Q1_11 VDDCE_11 VNWP VPW WEN0_11 WEN1_11
+  WENY0_11 WENY1_11 sram464x144BOTCAP2X2_RPT
XLEFT_COL_12 D0_12 D1_12 LOG0 Q0_12 Q1_12 VDDCE_12 VNWP VPW WEN0_12 WEN1_12
+  WENY0_12 WENY1_12 sram464x144BOTCAP2X2_RPT
XLEFT_COL_13 D0_13 D1_13 LOG0 Q0_13 Q1_13 VDDCE_13 VNWP VPW WEN0_13 WEN1_13
+  WENY0_13 WENY1_13 sram464x144BOTCAP2X2_RPT
XLEFT_COL_14 D0_14 D1_14 LOG0 Q0_14 Q1_14 VDDCE_14 VNWP VPW WEN0_14 WEN1_14
+  WENY0_14 WENY1_14 sram464x144BOTCAP2X2_RPT
XLEFT_COL_15 D0_15 D1_15 LOG0 Q0_15 Q1_15 VDDCE_15 VNWP VPW WEN0_15 WEN1_15
+  WENY0_15 WENY1_15 sram464x144BOTCAP2X2_RPT
XLEFT_COL_16 D0_16 D1_16 LOG0 Q0_16 Q1_16 VDDCE_16 VNWP VPW WEN0_16 WEN1_16
+  WENY0_16 WENY1_16 sram464x144BOTCAP2X2_RPT
XLEFT_COL_17 D0_17 D1_17 LOG0 Q0_17 Q1_17 VDDCE_17 VNWP VPW WEN0_17 WEN1_17
+  WENY0_17 WENY1_17 sram464x144BOTCAP2X2_RPT
XLEFT_COL_18 D0_18 D1_18 LOG0 Q0_18 Q1_18 VDDCE_18 VNWP VPW WEN0_18 WEN1_18
+  WENY0_18 WENY1_18 sram464x144BOTCAP2X2_RPT
XLEFT_COL_19 D0_19 D1_19 LOG0 Q0_19 Q1_19 VDDCE_19 VNWP VPW WEN0_19 WEN1_19
+  WENY0_19 WENY1_19 sram464x144BOTCAP2X2_RPT
XLEFT_COL_2 D0_2 D1_2 LOG0 Q0_2 Q1_2 VDDCE_2 VNWP VPW WEN0_2 WEN1_2 WENY0_2
+  WENY1_2 sram464x144BOTCAP2X2_RPT
XLEFT_COL_20 D0_20 D1_20 LOG0 Q0_20 Q1_20 VDDCE_20 VNWP VPW WEN0_20 WEN1_20
+  WENY0_20 WENY1_20 sram464x144BOTCAP2X2_RPT
XLEFT_COL_21 D0_21 D1_21 LOG0 Q0_21 Q1_21 VDDCE_21 VNWP VPW WEN0_21 WEN1_21
+  WENY0_21 WENY1_21 sram464x144BOTCAP2X2_RPT
XLEFT_COL_22 D0_22 D1_22 LOG0 Q0_22 Q1_22 VDDCE_22 VNWP VPW WEN0_22 WEN1_22
+  WENY0_22 WENY1_22 sram464x144BOTCAP2X2_RPT
XLEFT_COL_23 D0_23 D1_23 LOG0 Q0_23 Q1_23 VDDCE_23 VNWP VPW WEN0_23 WEN1_23
+  WENY0_23 WENY1_23 sram464x144BOTCAP2X2_RPT
XLEFT_COL_24 D0_24 D1_24 LOG0 Q0_24 Q1_24 VDDCE_24 VNWP VPW WEN0_24 WEN1_24
+  WENY0_24 WENY1_24 sram464x144BOTCAP2X2_RPT
XLEFT_COL_25 D0_25 D1_25 LOG0 Q0_25 Q1_25 VDDCE_25 VNWP VPW WEN0_25 WEN1_25
+  WENY0_25 WENY1_25 sram464x144BOTCAP2X2_RPT
XLEFT_COL_26 D0_26 D1_26 LOG0 Q0_26 Q1_26 VDDCE_26 VNWP VPW WEN0_26 WEN1_26
+  WENY0_26 WENY1_26 sram464x144BOTCAP2X2_RPT
XLEFT_COL_27 D0_27 D1_27 LOG0 Q0_27 Q1_27 VDDCE_27 VNWP VPW WEN0_27 WEN1_27
+  WENY0_27 WENY1_27 sram464x144BOTCAP2X2_RPT
XLEFT_COL_28 D0_28 D1_28 LOG0 Q0_28 Q1_28 VDDCE_28 VNWP VPW WEN0_28 WEN1_28
+  WENY0_28 WENY1_28 sram464x144BOTCAP2X2_RPT
XLEFT_COL_29 D0_29 D1_29 LOG0 Q0_29 Q1_29 VDDCE_29 VNWP VPW WEN0_29 WEN1_29
+  WENY0_29 WENY1_29 sram464x144BOTCAP2X2_RPT
XLEFT_COL_3 D0_3 D1_3 LOG0 Q0_3 Q1_3 VDDCE_3 VNWP VPW WEN0_3 WEN1_3 WENY0_3
+  WENY1_3 sram464x144BOTCAP2X2_RPT
XLEFT_COL_30 D0_30 D1_30 LOG0 Q0_30 Q1_30 VDDCE_30 VNWP VPW WEN0_30 WEN1_30
+  WENY0_30 WENY1_30 sram464x144BOTCAP2X2_RPT
XLEFT_COL_31 D0_31 D1_31 LOG0 Q0_31 Q1_31 VDDCE_31 VNWP VPW WEN0_31 WEN1_31
+  WENY0_31 WENY1_31 sram464x144BOTCAP2X2_RPT
XLEFT_COL_32 D0_32 D1_32 LOG0 Q0_32 Q1_32 VDDCE_32 VNWP VPW WEN0_32 WEN1_32
+  WENY0_32 WENY1_32 sram464x144BOTCAP2X2_RPT
XLEFT_COL_33 D0_33 D1_33 LOG0 Q0_33 Q1_33 VDDCE_33 VNWP VPW WEN0_33 WEN1_33
+  WENY0_33 WENY1_33 sram464x144BOTCAP2X2_RPT
XLEFT_COL_34 D0_34 D1_34 LOG0 Q0_34 Q1_34 VDDCE_34 VNWP VPW WEN0_34 WEN1_34
+  WENY0_34 WENY1_34 sram464x144BOTCAP2X2_RPT
XLEFT_COL_35 D0_35 D1_35 LOG0 Q0_35 Q1_35 VDDCE_35 VNWP VPW WEN0_35 WEN1_35
+  WENY0_35 WENY1_35 sram464x144BOTCAP2X2_RPT
XLEFT_COL_4 D0_4 D1_4 LOG0 Q0_4 Q1_4 VDDCE_4 VNWP VPW WEN0_4 WEN1_4 WENY0_4
+  WENY1_4 sram464x144BOTCAP2X2_RPT
XLEFT_COL_5 D0_5 D1_5 LOG0 Q0_5 Q1_5 VDDCE_5 VNWP VPW WEN0_5 WEN1_5 WENY0_5
+  WENY1_5 sram464x144BOTCAP2X2_RPT
XLEFT_COL_6 D0_6 D1_6 LOG0 Q0_6 Q1_6 VDDCE_6 VNWP VPW WEN0_6 WEN1_6 WENY0_6
+  WENY1_6 sram464x144BOTCAP2X2_RPT
XLEFT_COL_7 D0_7 D1_7 LOG0 Q0_7 Q1_7 VDDCE_7 VNWP VPW WEN0_7 WEN1_7 WENY0_7
+  WENY1_7 sram464x144BOTCAP2X2_RPT
XLEFT_COL_8 D0_8 D1_8 LOG0 Q0_8 Q1_8 VDDCE_8 VNWP VPW WEN0_8 WEN1_8 WENY0_8
+  WENY1_8 sram464x144BOTCAP2X2_RPT
XLEFT_COL_9 D0_9 D1_9 LOG0 Q0_9 Q1_9 VDDCE_9 VNWP VPW WEN0_9 WEN1_9 WENY0_9
+  WENY1_9 sram464x144BOTCAP2X2_RPT
XRIGHT LOG0 PSI_1 SI_1 VNWC_2 VNWP VPW VPW sram464x144BOTCORNER_WRAPT
XRIGHT_COL_0 D0_36 D1_36 LOG0 Q0_36 Q1_36 VDDCE_37 VNWP VPW WEN0_36 WEN1_36
+  WENY0_36 WENY1_36 sram464x144BOTCAP2X2_RPT
XRIGHT_COL_1 D0_37 D1_37 LOG0 Q0_37 Q1_37 VDDCE_38 VNWP VPW WEN0_37 WEN1_37
+  WENY0_37 WENY1_37 sram464x144BOTCAP2X2_RPT
XRIGHT_COL_10 D0_46 D1_46 LOG0 Q0_46 Q1_46 VDDCE_47 VNWP VPW WEN0_46 WEN1_46
+  WENY0_46 WENY1_46 sram464x144BOTCAP2X2_RPT
XRIGHT_COL_11 D0_47 D1_47 LOG0 Q0_47 Q1_47 VDDCE_48 VNWP VPW WEN0_47 WEN1_47
+  WENY0_47 WENY1_47 sram464x144BOTCAP2X2_RPT
XRIGHT_COL_12 D0_48 D1_48 LOG0 Q0_48 Q1_48 VDDCE_49 VNWP VPW WEN0_48 WEN1_48
+  WENY0_48 WENY1_48 sram464x144BOTCAP2X2_RPT
XRIGHT_COL_13 D0_49 D1_49 LOG0 Q0_49 Q1_49 VDDCE_50 VNWP VPW WEN0_49 WEN1_49
+  WENY0_49 WENY1_49 sram464x144BOTCAP2X2_RPT
XRIGHT_COL_14 D0_50 D1_50 LOG0 Q0_50 Q1_50 VDDCE_51 VNWP VPW WEN0_50 WEN1_50
+  WENY0_50 WENY1_50 sram464x144BOTCAP2X2_RPT
XRIGHT_COL_15 D0_51 D1_51 LOG0 Q0_51 Q1_51 VDDCE_52 VNWP VPW WEN0_51 WEN1_51
+  WENY0_51 WENY1_51 sram464x144BOTCAP2X2_RPT
XRIGHT_COL_16 D0_52 D1_52 LOG0 Q0_52 Q1_52 VDDCE_53 VNWP VPW WEN0_52 WEN1_52
+  WENY0_52 WENY1_52 sram464x144BOTCAP2X2_RPT
XRIGHT_COL_17 D0_53 D1_53 LOG0 Q0_53 Q1_53 VDDCE_54 VNWP VPW WEN0_53 WEN1_53
+  WENY0_53 WENY1_53 sram464x144BOTCAP2X2_RPT
XRIGHT_COL_18 D0_54 D1_54 LOG0 Q0_54 Q1_54 VDDCE_55 VNWP VPW WEN0_54 WEN1_54
+  WENY0_54 WENY1_54 sram464x144BOTCAP2X2_RPT
XRIGHT_COL_19 D0_55 D1_55 LOG0 Q0_55 Q1_55 VDDCE_56 VNWP VPW WEN0_55 WEN1_55
+  WENY0_55 WENY1_55 sram464x144BOTCAP2X2_RPT
XRIGHT_COL_2 D0_38 D1_38 LOG0 Q0_38 Q1_38 VDDCE_39 VNWP VPW WEN0_38 WEN1_38
+  WENY0_38 WENY1_38 sram464x144BOTCAP2X2_RPT
XRIGHT_COL_20 D0_56 D1_56 LOG0 Q0_56 Q1_56 VDDCE_57 VNWP VPW WEN0_56 WEN1_56
+  WENY0_56 WENY1_56 sram464x144BOTCAP2X2_RPT
XRIGHT_COL_21 D0_57 D1_57 LOG0 Q0_57 Q1_57 VDDCE_58 VNWP VPW WEN0_57 WEN1_57
+  WENY0_57 WENY1_57 sram464x144BOTCAP2X2_RPT
XRIGHT_COL_22 D0_58 D1_58 LOG0 Q0_58 Q1_58 VDDCE_59 VNWP VPW WEN0_58 WEN1_58
+  WENY0_58 WENY1_58 sram464x144BOTCAP2X2_RPT
XRIGHT_COL_23 D0_59 D1_59 LOG0 Q0_59 Q1_59 VDDCE_60 VNWP VPW WEN0_59 WEN1_59
+  WENY0_59 WENY1_59 sram464x144BOTCAP2X2_RPT
XRIGHT_COL_24 D0_60 D1_60 LOG0 Q0_60 Q1_60 VDDCE_61 VNWP VPW WEN0_60 WEN1_60
+  WENY0_60 WENY1_60 sram464x144BOTCAP2X2_RPT
XRIGHT_COL_25 D0_61 D1_61 LOG0 Q0_61 Q1_61 VDDCE_62 VNWP VPW WEN0_61 WEN1_61
+  WENY0_61 WENY1_61 sram464x144BOTCAP2X2_RPT
XRIGHT_COL_26 D0_62 D1_62 LOG0 Q0_62 Q1_62 VDDCE_63 VNWP VPW WEN0_62 WEN1_62
+  WENY0_62 WENY1_62 sram464x144BOTCAP2X2_RPT
XRIGHT_COL_27 D0_63 D1_63 LOG0 Q0_63 Q1_63 VDDCE_64 VNWP VPW WEN0_63 WEN1_63
+  WENY0_63 WENY1_63 sram464x144BOTCAP2X2_RPT
XRIGHT_COL_28 D0_64 D1_64 LOG0 Q0_64 Q1_64 VDDCE_65 VNWP VPW WEN0_64 WEN1_64
+  WENY0_64 WENY1_64 sram464x144BOTCAP2X2_RPT
XRIGHT_COL_29 D0_65 D1_65 LOG0 Q0_65 Q1_65 VDDCE_66 VNWP VPW WEN0_65 WEN1_65
+  WENY0_65 WENY1_65 sram464x144BOTCAP2X2_RPT
XRIGHT_COL_3 D0_39 D1_39 LOG0 Q0_39 Q1_39 VDDCE_40 VNWP VPW WEN0_39 WEN1_39
+  WENY0_39 WENY1_39 sram464x144BOTCAP2X2_RPT
XRIGHT_COL_30 D0_66 D1_66 LOG0 Q0_66 Q1_66 VDDCE_67 VNWP VPW WEN0_66 WEN1_66
+  WENY0_66 WENY1_66 sram464x144BOTCAP2X2_RPT
XRIGHT_COL_31 D0_67 D1_67 LOG0 Q0_67 Q1_67 VDDCE_68 VNWP VPW WEN0_67 WEN1_67
+  WENY0_67 WENY1_67 sram464x144BOTCAP2X2_RPT
XRIGHT_COL_32 D0_68 D1_68 LOG0 Q0_68 Q1_68 VDDCE_69 VNWP VPW WEN0_68 WEN1_68
+  WENY0_68 WENY1_68 sram464x144BOTCAP2X2_RPT
XRIGHT_COL_33 D0_69 D1_69 LOG0 Q0_69 Q1_69 VDDCE_70 VNWP VPW WEN0_69 WEN1_69
+  WENY0_69 WENY1_69 sram464x144BOTCAP2X2_RPT
XRIGHT_COL_34 D0_70 D1_70 LOG0 Q0_70 Q1_70 VDDCE_71 VNWP VPW WEN0_70 WEN1_70
+  WENY0_70 WENY1_70 sram464x144BOTCAP2X2_RPT
XRIGHT_COL_35 D0_71 D1_71 LOG0 Q0_71 Q1_71 VDDCE_72 VNWP VPW WEN0_71 WEN1_71
+  WENY0_71 WENY1_71 sram464x144BOTCAP2X2_RPT
XRIGHT_COL_4 D0_40 D1_40 LOG0 Q0_40 Q1_40 VDDCE_41 VNWP VPW WEN0_40 WEN1_40
+  WENY0_40 WENY1_40 sram464x144BOTCAP2X2_RPT
XRIGHT_COL_5 D0_41 D1_41 LOG0 Q0_41 Q1_41 VDDCE_42 VNWP VPW WEN0_41 WEN1_41
+  WENY0_41 WENY1_41 sram464x144BOTCAP2X2_RPT
XRIGHT_COL_6 D0_42 D1_42 LOG0 Q0_42 Q1_42 VDDCE_43 VNWP VPW WEN0_42 WEN1_42
+  WENY0_42 WENY1_42 sram464x144BOTCAP2X2_RPT
XRIGHT_COL_7 D0_43 D1_43 LOG0 Q0_43 Q1_43 VDDCE_44 VNWP VPW WEN0_43 WEN1_43
+  WENY0_43 WENY1_43 sram464x144BOTCAP2X2_RPT
XRIGHT_COL_8 D0_44 D1_44 LOG0 Q0_44 Q1_44 VDDCE_45 VNWP VPW WEN0_44 WEN1_44
+  WENY0_44 WENY1_44 sram464x144BOTCAP2X2_RPT
XRIGHT_COL_9 D0_45 D1_45 LOG0 Q0_45 Q1_45 VDDCE_46 VNWP VPW WEN0_45 WEN1_45
+  WENY0_45 WENY1_45 sram464x144BOTCAP2X2_RPT
.ENDS sram464x144BOTCAPROW
****
.SUBCKT sram464x144COLM2X2 BL0 BL1 BL2 BL3 BLPRECH D0 D1 DUMMY[0] DUMMY[1]
+  DUMMY[2] DUMMY[3] DUMMY[4] DUMMY[5] DUMMY[6] DUMMY[7] DWL LOG0 NACT_CC NBL0
+  NBL1 NBL2 NBL3 NSAE NWCLK NYR0 NYR1 SAO0 SAO1 SAPRECH VDDC VDDCE VDDPE VNWC
+  VNWP VPW VSS VSSE YW0 YW1
** sram464x144COLM2X2: 133 flat devices **
X_M_cd.I34.MXNA1 _CD.NBLPRECH BLPRECH VSS VPW N11LL_CKT W=0.395U L=0.04U
X_M_cd.I34.MXPA1 _CD.NBLPRECH BLPRECH VDDPE VNWP P11LL_CKT W=0.87U L=0.04U
X_M_cd.I46.MXNA1 _CD.SAE NSAE VSS VPW N11LL_CKT W=0.42U L=0.04U
X_M_cd.I46.MXPA1 _CD.SAE NSAE VDDPE VNWP P11LL_CKT W=0.505U L=0.04U
X_M_cd.I56.MXNA1 _CD.NSAPRECH SAPRECH _CD.I56.N1 VPW N11LL_CKT W=0.21U L=0.04U
X_M_cd.I56.MXNA2 _CD.I56.N1 NSAE VSS VPW N11LL_CKT W=0.21U L=0.04U
X_M_cd.I56.MXPA1 _CD.NSAPRECH SAPRECH VDDPE VNWP P11LL_CKT W=0.63U L=0.04U
X_M_cd.I56.MXPA2 _CD.NSAPRECH NSAE VDDPE VNWP P11LL_CKT W=0.375U L=0.04U
X_M_cd._cdrw0._mx0.MXN0 NBL0 YW0 WRZERO0 VPW N11LL_CKT W=0.58U L=0.04U
X_M_cd._cdrw0._mx0.MXN1 BL0 YW0 WRONE0 VPW N11LL_CKT W=0.58U L=0.04U
X_M_cd._cdrw0._mx0.MXP1 NBL0 _CD.NBLPRECH VDDPE VNWC P11LL_CKT W=0.45U L=0.04U
X_M_cd._cdrw0._mx0.MXP10 _CD._CDRW0._MX0.VVDP NACT_CC VDDPE VNWC P11LL_CKT
+  W=0.28U L=0.04U
X_M_cd._cdrw0._mx0.MXP3 _CD.NSD0 NYR0 NBL0 VNWC P11LL_CKT W=0.475U L=0.04U
X_M_cd._cdrw0._mx0.MXP4 _CD.SD0 NYR0 BL0 VNWC P11LL_CKT W=0.475U L=0.04U
X_M_cd._cdrw0._mx0.MXP5 NBL0 BL0 _CD._CDRW0._MX0.VVDP VNWC P11LL_CKT W=0.28U
+  L=0.04U
X_M_cd._cdrw0._mx0.MXP7 BL0 _CD.NBLPRECH VDDPE VNWC P11LL_CKT W=0.45U L=0.04U
X_M_cd._cdrw0._mx0.MXP8 NBL0 _CD.NBLPRECH BL0 VNWC P11LL_CKT W=0.45U L=0.04U
X_M_cd._cdrw0._mx0.MXP9 BL0 NBL0 _CD._CDRW0._MX0.VVDP VNWC P11LL_CKT W=0.28U
+  L=0.04U
X_M_cd._cdrw0._mx1.MXN0 NBL1 YW1 WRZERO0 VPW N11LL_CKT W=0.58U L=0.04U
X_M_cd._cdrw0._mx1.MXN1 BL1 YW1 WRONE0 VPW N11LL_CKT W=0.58U L=0.04U
X_M_cd._cdrw0._mx1.MXP1 NBL1 _CD.NBLPRECH VDDPE VNWC P11LL_CKT W=0.45U L=0.04U
X_M_cd._cdrw0._mx1.MXP10 _CD._CDRW0._MX1.VVDP NACT_CC VDDPE VNWC P11LL_CKT
+  W=0.28U L=0.04U
X_M_cd._cdrw0._mx1.MXP3 _CD.NSD0 NYR1 NBL1 VNWC P11LL_CKT W=0.475U L=0.04U
X_M_cd._cdrw0._mx1.MXP4 _CD.SD0 NYR1 BL1 VNWC P11LL_CKT W=0.475U L=0.04U
X_M_cd._cdrw0._mx1.MXP5 NBL1 BL1 _CD._CDRW0._MX1.VVDP VNWC P11LL_CKT W=0.28U
+  L=0.04U
X_M_cd._cdrw0._mx1.MXP7 BL1 _CD.NBLPRECH VDDPE VNWC P11LL_CKT W=0.45U L=0.04U
X_M_cd._cdrw0._mx1.MXP8 NBL1 _CD.NBLPRECH BL1 VNWC P11LL_CKT W=0.45U L=0.04U
X_M_cd._cdrw0._mx1.MXP9 BL1 NBL1 _CD._CDRW0._MX1.VVDP VNWC P11LL_CKT W=0.28U
+  L=0.04U
X_M_cd._cdrw1._mx0.MXN0 NBL2 YW0 WRZERO1 VPW N11LL_CKT W=0.58U L=0.04U
X_M_cd._cdrw1._mx0.MXN1 BL2 YW0 WRONE1 VPW N11LL_CKT W=0.58U L=0.04U
X_M_cd._cdrw1._mx0.MXP1 NBL2 _CD.NBLPRECH VDDPE VNWC P11LL_CKT W=0.45U L=0.04U
X_M_cd._cdrw1._mx0.MXP10 _CD._CDRW1._MX0.VVDP NACT_CC VDDPE VNWC P11LL_CKT
+  W=0.28U L=0.04U
X_M_cd._cdrw1._mx0.MXP3 _CD.NSD1 NYR0 NBL2 VNWC P11LL_CKT W=0.475U L=0.04U
X_M_cd._cdrw1._mx0.MXP4 _CD.SD1 NYR0 BL2 VNWC P11LL_CKT W=0.475U L=0.04U
X_M_cd._cdrw1._mx0.MXP5 NBL2 BL2 _CD._CDRW1._MX0.VVDP VNWC P11LL_CKT W=0.28U
+  L=0.04U
X_M_cd._cdrw1._mx0.MXP7 BL2 _CD.NBLPRECH VDDPE VNWC P11LL_CKT W=0.45U L=0.04U
X_M_cd._cdrw1._mx0.MXP8 NBL2 _CD.NBLPRECH BL2 VNWC P11LL_CKT W=0.45U L=0.04U
X_M_cd._cdrw1._mx0.MXP9 BL2 NBL2 _CD._CDRW1._MX0.VVDP VNWC P11LL_CKT W=0.28U
+  L=0.04U
X_M_cd._cdrw1._mx1.MXN0 NBL3 YW1 WRZERO1 VPW N11LL_CKT W=0.58U L=0.04U
X_M_cd._cdrw1._mx1.MXN1 BL3 YW1 WRONE1 VPW N11LL_CKT W=0.58U L=0.04U
X_M_cd._cdrw1._mx1.MXP1 NBL3 _CD.NBLPRECH VDDPE VNWC P11LL_CKT W=0.45U L=0.04U
X_M_cd._cdrw1._mx1.MXP10 _CD._CDRW1._MX1.VVDP NACT_CC VDDPE VNWC P11LL_CKT
+  W=0.28U L=0.04U
X_M_cd._cdrw1._mx1.MXP3 _CD.NSD1 NYR1 NBL3 VNWC P11LL_CKT W=0.475U L=0.04U
X_M_cd._cdrw1._mx1.MXP4 _CD.SD1 NYR1 BL3 VNWC P11LL_CKT W=0.475U L=0.04U
X_M_cd._cdrw1._mx1.MXP5 NBL3 BL3 _CD._CDRW1._MX1.VVDP VNWC P11LL_CKT W=0.28U
+  L=0.04U
X_M_cd._cdrw1._mx1.MXP7 BL3 _CD.NBLPRECH VDDPE VNWC P11LL_CKT W=0.45U L=0.04U
X_M_cd._cdrw1._mx1.MXP8 NBL3 _CD.NBLPRECH BL3 VNWC P11LL_CKT W=0.45U L=0.04U
X_M_cd._cdrw1._mx1.MXP9 BL3 NBL3 _CD._CDRW1._MX1.VVDP VNWC P11LL_CKT W=0.28U
+  L=0.04U
X_M_cd._dwl_load.MXNpgl VSS DWL VSS VPW N11LL_CKT W=1.2U L=0.06U
X_M_cd._sa0.MXN17 _CD.NSD0 _CD.SD0 _CD.NET108 VPW N11LL_CKT W=1.86U L=0.085U
X_M_cd._sa0.MXN18 _CD.NET108 _CD.SAE VSS VPW N11LL_CKT W=0.93U L=0.04U
X_M_cd._sa0.MXN19 _CD.SD0 _CD.NSD0 _CD.NET108 VPW N11LL_CKT W=1.86U L=0.085U
X_M_cd._sa0.MXP24 _CD.NSD0 _CD.NSAPRECH VDDPE VNWP P11LL_CKT W=0.46U L=0.04U
X_M_cd._sa0.MXP25 _CD.NSD0 _CD.NSAPRECH _CD.SD0 VNWP P11LL_CKT W=0.46U L=0.04U
X_M_cd._sa0.MXP26 _CD.SD0 _CD.NSAPRECH VDDPE VNWP P11LL_CKT W=0.46U L=0.04U
X_M_cd._sa0.MXP27 _CD.NSD0 _CD.SD0 VDDPE VNWP P11LL_CKT W=0.465U L=0.04U
X_M_cd._sa0.MXP28 _CD.SD0 _CD.NSD0 VDDPE VNWP P11LL_CKT W=0.465U L=0.04U
X_M_cd._sa1.MXN17 _CD.NSD1 _CD.SD1 _CD.NET117 VPW N11LL_CKT W=1.86U L=0.085U
X_M_cd._sa1.MXN18 _CD.NET117 _CD.SAE VSS VPW N11LL_CKT W=0.93U L=0.04U
X_M_cd._sa1.MXN19 _CD.SD1 _CD.NSD1 _CD.NET117 VPW N11LL_CKT W=1.86U L=0.085U
X_M_cd._sa1.MXP24 _CD.NSD1 _CD.NSAPRECH VDDPE VNWP P11LL_CKT W=0.46U L=0.04U
X_M_cd._sa1.MXP25 _CD.NSD1 _CD.NSAPRECH _CD.SD1 VNWP P11LL_CKT W=0.46U L=0.04U
X_M_cd._sa1.MXP26 _CD.SD1 _CD.NSAPRECH VDDPE VNWP P11LL_CKT W=0.46U L=0.04U
X_M_cd._sa1.MXP27 _CD.NSD1 _CD.SD1 VDDPE VNWP P11LL_CKT W=0.465U L=0.04U
X_M_cd._sa1.MXP28 _CD.SD1 _CD.NSD1 VDDPE VNWP P11LL_CKT W=0.465U L=0.04U
X_M_cd._salat0.I62.MXNA1 SAO0 _CD._SALAT0.SD_LAT VSS VPW N11LL_CKT W=0.505U
+  L=0.04U
X_M_cd._salat0.I62.MXPA1 SAO0 _CD._SALAT0.SD_LAT VDDPE VNWP P11LL_CKT W=0.63U
+  L=0.04U
X_M_cd._salat0.I63.MXNA1 _CD._SALAT0.IRD _CD._SALAT0.SD_LAT VSS VPW N11LL_CKT
+  W=0.145U L=0.04U
X_M_cd._salat0.I63.MXPA1 _CD._SALAT0.IRD _CD._SALAT0.SD_LAT VDDPE VNWP
+  P11LL_CKT W=0.165U L=0.04U
X_M_cd._salat0.I82.MXNA1 _CD._SALAT0.NLAT_E _CD.SAE VSS VPW N11LL_CKT W=0.145U
+  L=0.04U
X_M_cd._salat0.I82.MXPA1 _CD._SALAT0.NLAT_E _CD.SAE VDDPE VNWP P11LL_CKT
+  W=0.25U L=0.04U
X_M_cd._salat0.MXN8 _CD._SALAT0.N1B _CD._SALAT0.IRD VSS VPW N11LL_CKT W=0.145U
+  L=0.04U
X_M_cd._salat0.MXN9 _CD._SALAT0.SD_LAT _CD._SALAT0.NLAT_E _CD._SALAT0.N1B VPW
+  N11LL_CKT W=0.145U L=0.04U
X_M_cd._salat0.MXP6 _CD._SALAT0.SD_LAT _CD.SAE _CD._SALAT0.P1B VNWP P11LL_CKT
+  W=0.35U L=0.04U
X_M_cd._salat0.MXP7 _CD._SALAT0.P1B _CD._SALAT0.IRD VDDPE VNWP P11LL_CKT
+  W=0.35U L=0.04U
X_M_cd._salat0.MXPs _CD._SALAT0.SD_LAT _CD.NSD0 _CD._SALAT0.P1A VNWP P11LL_CKT
+  W=0.56U L=0.04U
X_M_cd._salat0.MX_ndmy _CD._SALAT0.NSD_DUM _CD.SD0 _CD._SALAT0.N1A VPW
+  N11LL_CKT W=0.42U L=0.04U
X_M_cd._salat0.MX_nlat _CD._SALAT0.N1A _CD.SAE VSS VPW N11LL_CKT W=0.42U
+  L=0.04U
X_M_cd._salat0.MX_pdmy _CD._SALAT0.NSD_DUM _CD.SD0 _CD._SALAT0.P1A VNWP
+  P11LL_CKT W=0.56U L=0.04U
X_M_cd._salat0.MX_pnsae _CD._SALAT0.P1A _CD._SALAT0.NLAT_E VDDPE VNWP
+  P11LL_CKT W=0.56U L=0.04U
X_M_cd._salat0.MX_sd_n _CD._SALAT0.SD_LAT _CD.NSD0 _CD._SALAT0.N1A VPW
+  N11LL_CKT W=0.42U L=0.04U
X_M_cd._salat1.I62.MXNA1 SAO1 _CD._SALAT1.SD_LAT VSS VPW N11LL_CKT W=0.505U
+  L=0.04U
X_M_cd._salat1.I62.MXPA1 SAO1 _CD._SALAT1.SD_LAT VDDPE VNWP P11LL_CKT W=0.63U
+  L=0.04U
X_M_cd._salat1.I63.MXNA1 _CD._SALAT1.IRD _CD._SALAT1.SD_LAT VSS VPW N11LL_CKT
+  W=0.145U L=0.04U
X_M_cd._salat1.I63.MXPA1 _CD._SALAT1.IRD _CD._SALAT1.SD_LAT VDDPE VNWP
+  P11LL_CKT W=0.165U L=0.04U
X_M_cd._salat1.I82.MXNA1 _CD._SALAT1.NLAT_E _CD.SAE VSS VPW N11LL_CKT W=0.145U
+  L=0.04U
X_M_cd._salat1.I82.MXPA1 _CD._SALAT1.NLAT_E _CD.SAE VDDPE VNWP P11LL_CKT
+  W=0.25U L=0.04U
X_M_cd._salat1.MXN8 _CD._SALAT1.N1B _CD._SALAT1.IRD VSS VPW N11LL_CKT W=0.145U
+  L=0.04U
X_M_cd._salat1.MXN9 _CD._SALAT1.SD_LAT _CD._SALAT1.NLAT_E _CD._SALAT1.N1B VPW
+  N11LL_CKT W=0.145U L=0.04U
X_M_cd._salat1.MXP6 _CD._SALAT1.SD_LAT _CD.SAE _CD._SALAT1.P1B VNWP P11LL_CKT
+  W=0.35U L=0.04U
X_M_cd._salat1.MXP7 _CD._SALAT1.P1B _CD._SALAT1.IRD VDDPE VNWP P11LL_CKT
+  W=0.35U L=0.04U
X_M_cd._salat1.MXPs _CD._SALAT1.SD_LAT _CD.NSD1 _CD._SALAT1.P1A VNWP P11LL_CKT
+  W=0.56U L=0.04U
X_M_cd._salat1.MX_ndmy _CD._SALAT1.NSD_DUM _CD.SD1 _CD._SALAT1.N1A VPW
+  N11LL_CKT W=0.42U L=0.04U
X_M_cd._salat1.MX_nlat _CD._SALAT1.N1A _CD.SAE VSS VPW N11LL_CKT W=0.42U
+  L=0.04U
X_M_cd._salat1.MX_pdmy _CD._SALAT1.NSD_DUM _CD.SD1 _CD._SALAT1.P1A VNWP
+  P11LL_CKT W=0.56U L=0.04U
X_M_cd._salat1.MX_pnsae _CD._SALAT1.P1A _CD._SALAT1.NLAT_E VDDPE VNWP
+  P11LL_CKT W=0.56U L=0.04U
X_M_cd._salat1.MX_sd_n _CD._SALAT1.SD_LAT _CD.NSD1 _CD._SALAT1.N1A VPW
+  N11LL_CKT W=0.42U L=0.04U
X_M_wr.I156.MXNA1 WRZERO0 _WR.D_LAT0 VSS VPW N11LL_CKT W=1.23U L=0.04U
X_M_wr.I156.MXPA1 WRZERO0 _WR.D_LAT0 VDDPE VNWP P11LL_CKT W=0.56U L=0.04U
X_M_wr.I165.MXNA1 WRONE0 _WR.IND_LAT0 VSS VPW N11LL_CKT W=1.23U L=0.04U
X_M_wr.I165.MXPA1 WRONE0 _WR.IND_LAT0 VDDPE VNWP P11LL_CKT W=0.56U L=0.04U
X_M_wr.I167.MXNA1 WRONE1 _WR.IND_LAT1 VSS VPW N11LL_CKT W=1.23U L=0.04U
X_M_wr.I167.MXPA1 WRONE1 _WR.IND_LAT1 VDDPE VNWP P11LL_CKT W=0.56U L=0.04U
X_M_wr.I168.MXNA1 WRZERO1 _WR.D_LAT1 VSS VPW N11LL_CKT W=1.23U L=0.04U
X_M_wr.I168.MXPA1 WRZERO1 _WR.D_LAT1 VDDPE VNWP P11LL_CKT W=0.56U L=0.04U
X_M_wr.I171.MXNA1 _WR.IND_LAT0 _WR.D_LAT0 VSS VPW N11LL_CKT W=0.21U L=0.04U
X_M_wr.I171.MXPA1 _WR.IND_LAT0 _WR.D_LAT0 VDDPE VNWP P11LL_CKT W=0.42U L=0.04U
X_M_wr.I172.MXNA1 _WR.IND_LAT1 _WR.D_LAT1 VSS VPW N11LL_CKT W=0.21U L=0.04U
X_M_wr.I172.MXPA1 _WR.IND_LAT1 _WR.D_LAT1 VDDPE VNWP P11LL_CKT W=0.42U L=0.04U
X_M_wr.I194.MXNA1 _WR.WCLK NWCLK VSS VPW N11LL_CKT W=0.14U L=0.04U
X_M_wr.I194.MXPA1 _WR.WCLK NWCLK VDDPE VNWP P11LL_CKT W=0.28U L=0.04U
X_M_wr.IV_WrClk.MXNA1 _WR.INWCLK _WR.WCLK VSS VPW N11LL_CKT W=0.14U L=0.04U
X_M_wr.IV_WrClk.MXPA1 _WR.INWCLK _WR.WCLK VDDPE VNWP P11LL_CKT W=0.28U L=0.04U
X_M_wr._dlat0.I47.MXNA1 _WR._DLAT0.ND D0 VSS VPW N11LL_CKT W=0.28U L=0.04U
X_M_wr._dlat0.I47.MXPA1 _WR._DLAT0.ND D0 VDDPE VNWP P11LL_CKT W=0.42U L=0.04U
X_M_wr._dlat0.I48.MXNOE _WR.ND_LAT0 _WR.INWCLK _WR._DLAT0.ND VPW N11LL_CKT
+  W=0.28U L=0.04U
X_M_wr._dlat0.I48.MXPOEN _WR.ND_LAT0 _WR.WCLK _WR._DLAT0.ND VNWP P11LL_CKT
+  W=0.42U L=0.04U
X_M_wr._dlat0.I50.MXNA1 _WR.D_LAT0 _WR.ND_LAT0 VSS VPW N11LL_CKT W=0.28U
+  L=0.04U
X_M_wr._dlat0.I50.MXPA1 _WR.D_LAT0 _WR.ND_LAT0 VDDPE VNWP P11LL_CKT W=0.42U
+  L=0.04U
X_M_wr._dlat0.I55.MXNA1 _WR._DLAT0.I55.N1 _WR.D_LAT0 VSS VPW N11LL_CKT W=0.15U
+  L=0.04U
X_M_wr._dlat0.I55.MXNOE _WR.ND_LAT0 _WR.WCLK _WR._DLAT0.I55.N1 VPW N11LL_CKT
+  W=0.15U L=0.04U
X_M_wr._dlat0.I55.MXPA1 _WR._DLAT0.I55.P1 _WR.D_LAT0 VDDPE VNWP P11LL_CKT
+  W=0.15U L=0.04U
X_M_wr._dlat0.I55.MXPOEN _WR.ND_LAT0 _WR.INWCLK _WR._DLAT0.I55.P1 VNWP
+  P11LL_CKT W=0.15U L=0.04U
X_M_wr._dlat1.I47.MXNA1 _WR._DLAT1.ND D1 VSS VPW N11LL_CKT W=0.28U L=0.04U
X_M_wr._dlat1.I47.MXPA1 _WR._DLAT1.ND D1 VDDPE VNWP P11LL_CKT W=0.42U L=0.04U
X_M_wr._dlat1.I48.MXNOE _WR.ND_LAT1 _WR.INWCLK _WR._DLAT1.ND VPW N11LL_CKT
+  W=0.28U L=0.04U
X_M_wr._dlat1.I48.MXPOEN _WR.ND_LAT1 _WR.WCLK _WR._DLAT1.ND VNWP P11LL_CKT
+  W=0.42U L=0.04U
X_M_wr._dlat1.I50.MXNA1 _WR.D_LAT1 _WR.ND_LAT1 VSS VPW N11LL_CKT W=0.28U
+  L=0.04U
X_M_wr._dlat1.I50.MXPA1 _WR.D_LAT1 _WR.ND_LAT1 VDDPE VNWP P11LL_CKT W=0.42U
+  L=0.04U
X_M_wr._dlat1.I55.MXNA1 _WR._DLAT1.I55.N1 _WR.D_LAT1 VSS VPW N11LL_CKT W=0.15U
+  L=0.04U
X_M_wr._dlat1.I55.MXNOE _WR.ND_LAT1 _WR.WCLK _WR._DLAT1.I55.N1 VPW N11LL_CKT
+  W=0.15U L=0.04U
X_M_wr._dlat1.I55.MXPA1 _WR._DLAT1.I55.P1 _WR.D_LAT1 VDDPE VNWP P11LL_CKT
+  W=0.15U L=0.04U
X_M_wr._dlat1.I55.MXPOEN _WR.ND_LAT1 _WR.INWCLK _WR._DLAT1.I55.P1 VNWP
+  P11LL_CKT W=0.15U L=0.04U
.ENDS sram464x144COLM2X2
****
.SUBCKT sram464x144IOCDM_L BL0_0 BL0_1 BL0_2 BL0_3 BL0_4 BL0_5 BL0_6 BL0_7
+  BL0_8 BL0_9 BL0_10 BL0_11 BL0_12 BL0_13 BL0_14 BL0_15 BL0_16 BL0_17 BL0_18
+  BL0_19 BL0_20 BL0_21 BL0_22 BL0_23 BL0_24 BL0_25 BL0_26 BL0_27 BL0_28
+  BL0_29 BL0_30 BL0_31 BL0_32 BL0_33 BL0_34 BL0_35 BL1_0 BL1_1 BL1_2 BL1_3
+  BL1_4 BL1_5 BL1_6 BL1_7 BL1_8 BL1_9 BL1_10 BL1_11 BL1_12 BL1_13 BL1_14
+  BL1_15 BL1_16 BL1_17 BL1_18 BL1_19 BL1_20 BL1_21 BL1_22 BL1_23 BL1_24
+  BL1_25 BL1_26 BL1_27 BL1_28 BL1_29 BL1_30 BL1_31 BL1_32 BL1_33 BL1_34
+  BL1_35 BL2_0 BL2_1 BL2_2 BL2_3 BL2_4 BL2_5 BL2_6 BL2_7 BL2_8 BL2_9 BL2_10
+  BL2_11 BL2_12 BL2_13 BL2_14 BL2_15 BL2_16 BL2_17 BL2_18 BL2_19 BL2_20
+  BL2_21 BL2_22 BL2_23 BL2_24 BL2_25 BL2_26 BL2_27 BL2_28 BL2_29 BL2_30
+  BL2_31 BL2_32 BL2_33 BL2_34 BL2_35 BL3_0 BL3_1 BL3_2 BL3_3 BL3_4 BL3_5
+  BL3_6 BL3_7 BL3_8 BL3_9 BL3_10 BL3_11 BL3_12 BL3_13 BL3_14 BL3_15 BL3_16
+  BL3_17 BL3_18 BL3_19 BL3_20 BL3_21 BL3_22 BL3_23 BL3_24 BL3_25 BL3_26
+  BL3_27 BL3_28 BL3_29 BL3_30 BL3_31 BL3_32 BL3_33 BL3_34 BL3_35 BLPRECH D0_0
+  D0_1 D0_2 D0_3 D0_4 D0_5 D0_6 D0_7 D0_8 D0_9 D0_10 D0_11 D0_12 D0_13 D0_14
+  D0_15 D0_16 D0_17 D0_18 D0_19 D0_20 D0_21 D0_22 D0_23 D0_24 D0_25 D0_26
+  D0_27 D0_28 D0_29 D0_30 D0_31 D0_32 D0_33 D0_34 D0_35 D1_0 D1_1 D1_2 D1_3
+  D1_4 D1_5 D1_6 D1_7 D1_8 D1_9 D1_10 D1_11 D1_12 D1_13 D1_14 D1_15 D1_16
+  D1_17 D1_18 D1_19 D1_20 D1_21 D1_22 D1_23 D1_24 D1_25 D1_26 D1_27 D1_28
+  D1_29 D1_30 D1_31 D1_32 D1_33 D1_34 D1_35 DUMMY[0]_0 DUMMY[0]_1 DUMMY[0]_2
+  DUMMY[0]_3 DUMMY[0]_4 DUMMY[0]_5 DUMMY[0]_6 DUMMY[0]_7 DUMMY[0]_8
+  DUMMY[0]_9 DUMMY[0]_10 DUMMY[0]_11 DUMMY[0]_12 DUMMY[0]_13 DUMMY[0]_14
+  DUMMY[0]_15 DUMMY[0]_16 DUMMY[0]_17 DUMMY[0]_18 DUMMY[0]_19 DUMMY[0]_20
+  DUMMY[0]_21 DUMMY[0]_22 DUMMY[0]_23 DUMMY[0]_24 DUMMY[0]_25 DUMMY[0]_26
+  DUMMY[0]_27 DUMMY[0]_28 DUMMY[0]_29 DUMMY[0]_30 DUMMY[0]_31 DUMMY[0]_32
+  DUMMY[0]_33 DUMMY[0]_34 DUMMY[0]_35 DUMMY[1]_0 DUMMY[1]_1 DUMMY[1]_2
+  DUMMY[1]_3 DUMMY[1]_4 DUMMY[1]_5 DUMMY[1]_6 DUMMY[1]_7 DUMMY[1]_8
+  DUMMY[1]_9 DUMMY[1]_10 DUMMY[1]_11 DUMMY[1]_12 DUMMY[1]_13 DUMMY[1]_14
+  DUMMY[1]_15 DUMMY[1]_16 DUMMY[1]_17 DUMMY[1]_18 DUMMY[1]_19 DUMMY[1]_20
+  DUMMY[1]_21 DUMMY[1]_22 DUMMY[1]_23 DUMMY[1]_24 DUMMY[1]_25 DUMMY[1]_26
+  DUMMY[1]_27 DUMMY[1]_28 DUMMY[1]_29 DUMMY[1]_30 DUMMY[1]_31 DUMMY[1]_32
+  DUMMY[1]_33 DUMMY[1]_34 DUMMY[1]_35 DUMMY[2]_0 DUMMY[2]_1 DUMMY[2]_2
+  DUMMY[2]_3 DUMMY[2]_4 DUMMY[2]_5 DUMMY[2]_6 DUMMY[2]_7 DUMMY[2]_8
+  DUMMY[2]_9 DUMMY[2]_10 DUMMY[2]_11 DUMMY[2]_12 DUMMY[2]_13 DUMMY[2]_14
+  DUMMY[2]_15 DUMMY[2]_16 DUMMY[2]_17 DUMMY[2]_18 DUMMY[2]_19 DUMMY[2]_20
+  DUMMY[2]_21 DUMMY[2]_22 DUMMY[2]_23 DUMMY[2]_24 DUMMY[2]_25 DUMMY[2]_26
+  DUMMY[2]_27 DUMMY[2]_28 DUMMY[2]_29 DUMMY[2]_30 DUMMY[2]_31 DUMMY[2]_32
+  DUMMY[2]_33 DUMMY[2]_34 DUMMY[2]_35 DUMMY[3]_0 DUMMY[3]_1 DUMMY[3]_2
+  DUMMY[3]_3 DUMMY[3]_4 DUMMY[3]_5 DUMMY[3]_6 DUMMY[3]_7 DUMMY[3]_8
+  DUMMY[3]_9 DUMMY[3]_10 DUMMY[3]_11 DUMMY[3]_12 DUMMY[3]_13 DUMMY[3]_14
+  DUMMY[3]_15 DUMMY[3]_16 DUMMY[3]_17 DUMMY[3]_18 DUMMY[3]_19 DUMMY[3]_20
+  DUMMY[3]_21 DUMMY[3]_22 DUMMY[3]_23 DUMMY[3]_24 DUMMY[3]_25 DUMMY[3]_26
+  DUMMY[3]_27 DUMMY[3]_28 DUMMY[3]_29 DUMMY[3]_30 DUMMY[3]_31 DUMMY[3]_32
+  DUMMY[3]_33 DUMMY[3]_34 DUMMY[3]_35 DUMMY[4]_0 DUMMY[4]_1 DUMMY[4]_2
+  DUMMY[4]_3 DUMMY[4]_4 DUMMY[4]_5 DUMMY[4]_6 DUMMY[4]_7 DUMMY[4]_8
+  DUMMY[4]_9 DUMMY[4]_10 DUMMY[4]_11 DUMMY[4]_12 DUMMY[4]_13 DUMMY[4]_14
+  DUMMY[4]_15 DUMMY[4]_16 DUMMY[4]_17 DUMMY[4]_18 DUMMY[4]_19 DUMMY[4]_20
+  DUMMY[4]_21 DUMMY[4]_22 DUMMY[4]_23 DUMMY[4]_24 DUMMY[4]_25 DUMMY[4]_26
+  DUMMY[4]_27 DUMMY[4]_28 DUMMY[4]_29 DUMMY[4]_30 DUMMY[4]_31 DUMMY[4]_32
+  DUMMY[4]_33 DUMMY[4]_34 DUMMY[4]_35 DUMMY[5]_0 DUMMY[5]_1 DUMMY[5]_2
+  DUMMY[5]_3 DUMMY[5]_4 DUMMY[5]_5 DUMMY[5]_6 DUMMY[5]_7 DUMMY[5]_8
+  DUMMY[5]_9 DUMMY[5]_10 DUMMY[5]_11 DUMMY[5]_12 DUMMY[5]_13 DUMMY[5]_14
+  DUMMY[5]_15 DUMMY[5]_16 DUMMY[5]_17 DUMMY[5]_18 DUMMY[5]_19 DUMMY[5]_20
+  DUMMY[5]_21 DUMMY[5]_22 DUMMY[5]_23 DUMMY[5]_24 DUMMY[5]_25 DUMMY[5]_26
+  DUMMY[5]_27 DUMMY[5]_28 DUMMY[5]_29 DUMMY[5]_30 DUMMY[5]_31 DUMMY[5]_32
+  DUMMY[5]_33 DUMMY[5]_34 DUMMY[5]_35 DUMMY[6]_0 DUMMY[6]_1 DUMMY[6]_2
+  DUMMY[6]_3 DUMMY[6]_4 DUMMY[6]_5 DUMMY[6]_6 DUMMY[6]_7 DUMMY[6]_8
+  DUMMY[6]_9 DUMMY[6]_10 DUMMY[6]_11 DUMMY[6]_12 DUMMY[6]_13 DUMMY[6]_14
+  DUMMY[6]_15 DUMMY[6]_16 DUMMY[6]_17 DUMMY[6]_18 DUMMY[6]_19 DUMMY[6]_20
+  DUMMY[6]_21 DUMMY[6]_22 DUMMY[6]_23 DUMMY[6]_24 DUMMY[6]_25 DUMMY[6]_26
+  DUMMY[6]_27 DUMMY[6]_28 DUMMY[6]_29 DUMMY[6]_30 DUMMY[6]_31 DUMMY[6]_32
+  DUMMY[6]_33 DUMMY[6]_34 DUMMY[6]_35 DUMMY[7]_0 DUMMY[7]_1 DUMMY[7]_2
+  DUMMY[7]_3 DUMMY[7]_4 DUMMY[7]_5 DUMMY[7]_6 DUMMY[7]_7 DUMMY[7]_8
+  DUMMY[7]_9 DUMMY[7]_10 DUMMY[7]_11 DUMMY[7]_12 DUMMY[7]_13 DUMMY[7]_14
+  DUMMY[7]_15 DUMMY[7]_16 DUMMY[7]_17 DUMMY[7]_18 DUMMY[7]_19 DUMMY[7]_20
+  DUMMY[7]_21 DUMMY[7]_22 DUMMY[7]_23 DUMMY[7]_24 DUMMY[7]_25 DUMMY[7]_26
+  DUMMY[7]_27 DUMMY[7]_28 DUMMY[7]_29 DUMMY[7]_30 DUMMY[7]_31 DUMMY[7]_32
+  DUMMY[7]_33 DUMMY[7]_34 DUMMY[7]_35 DWL LOG0 NACT_CC NBL0_0 NBL0_1 NBL0_2
+  NBL0_3 NBL0_4 NBL0_5 NBL0_6 NBL0_7 NBL0_8 NBL0_9 NBL0_10 NBL0_11 NBL0_12
+  NBL0_13 NBL0_14 NBL0_15 NBL0_16 NBL0_17 NBL0_18 NBL0_19 NBL0_20 NBL0_21
+  NBL0_22 NBL0_23 NBL0_24 NBL0_25 NBL0_26 NBL0_27 NBL0_28 NBL0_29 NBL0_30
+  NBL0_31 NBL0_32 NBL0_33 NBL0_34 NBL0_35 NBL1_0 NBL1_1 NBL1_2 NBL1_3 NBL1_4
+  NBL1_5 NBL1_6 NBL1_7 NBL1_8 NBL1_9 NBL1_10 NBL1_11 NBL1_12 NBL1_13 NBL1_14
+  NBL1_15 NBL1_16 NBL1_17 NBL1_18 NBL1_19 NBL1_20 NBL1_21 NBL1_22 NBL1_23
+  NBL1_24 NBL1_25 NBL1_26 NBL1_27 NBL1_28 NBL1_29 NBL1_30 NBL1_31 NBL1_32
+  NBL1_33 NBL1_34 NBL1_35 NBL2_0 NBL2_1 NBL2_2 NBL2_3 NBL2_4 NBL2_5 NBL2_6
+  NBL2_7 NBL2_8 NBL2_9 NBL2_10 NBL2_11 NBL2_12 NBL2_13 NBL2_14 NBL2_15
+  NBL2_16 NBL2_17 NBL2_18 NBL2_19 NBL2_20 NBL2_21 NBL2_22 NBL2_23 NBL2_24
+  NBL2_25 NBL2_26 NBL2_27 NBL2_28 NBL2_29 NBL2_30 NBL2_31 NBL2_32 NBL2_33
+  NBL2_34 NBL2_35 NBL3_0 NBL3_1 NBL3_2 NBL3_3 NBL3_4 NBL3_5 NBL3_6 NBL3_7
+  NBL3_8 NBL3_9 NBL3_10 NBL3_11 NBL3_12 NBL3_13 NBL3_14 NBL3_15 NBL3_16
+  NBL3_17 NBL3_18 NBL3_19 NBL3_20 NBL3_21 NBL3_22 NBL3_23 NBL3_24 NBL3_25
+  NBL3_26 NBL3_27 NBL3_28 NBL3_29 NBL3_30 NBL3_31 NBL3_32 NBL3_33 NBL3_34
+  NBL3_35 NSAE NWCLK NYR0 NYR1 SAO0_0 SAO0_1 SAO0_2 SAO0_3 SAO0_4 SAO0_5
+  SAO0_6 SAO0_7 SAO0_8 SAO0_9 SAO0_10 SAO0_11 SAO0_12 SAO0_13 SAO0_14 SAO0_15
+  SAO0_16 SAO0_17 SAO0_18 SAO0_19 SAO0_20 SAO0_21 SAO0_22 SAO0_23 SAO0_24
+  SAO0_25 SAO0_26 SAO0_27 SAO0_28 SAO0_29 SAO0_30 SAO0_31 SAO0_32 SAO0_33
+  SAO0_34 SAO0_35 SAO1_0 SAO1_1 SAO1_2 SAO1_3 SAO1_4 SAO1_5 SAO1_6 SAO1_7
+  SAO1_8 SAO1_9 SAO1_10 SAO1_11 SAO1_12 SAO1_13 SAO1_14 SAO1_15 SAO1_16
+  SAO1_17 SAO1_18 SAO1_19 SAO1_20 SAO1_21 SAO1_22 SAO1_23 SAO1_24 SAO1_25
+  SAO1_26 SAO1_27 SAO1_28 SAO1_29 SAO1_30 SAO1_31 SAO1_32 SAO1_33 SAO1_34
+  SAO1_35 SAPRECH VDDCE VDDC_0 VDDC_1 VDDC_2 VDDC_3 VDDC_4 VDDC_5 VDDC_6
+  VDDC_7 VDDC_8 VDDC_9 VDDC_10 VDDC_11 VDDC_12 VDDC_13 VDDC_14 VDDC_15
+  VDDC_16 VDDC_17 VDDC_18 VDDC_19 VDDC_20 VDDC_21 VDDC_22 VDDC_23 VDDC_24
+  VDDC_25 VDDC_26 VDDC_27 VDDC_28 VDDC_29 VDDC_30 VDDC_31 VDDC_32 VDDC_33
+  VDDC_34 VDDC_35 VDDPE VNWC_0 VNWC_1 VNWC_2 VNWC_3 VNWC_4 VNWC_5 VNWC_6
+  VNWC_7 VNWC_8 VNWC_9 VNWC_10 VNWC_11 VNWC_12 VNWC_13 VNWC_14 VNWC_15
+  VNWC_16 VNWC_17 VNWC_18 VNWC_19 VNWC_20 VNWC_21 VNWC_22 VNWC_23 VNWC_24
+  VNWC_25 VNWC_26 VNWC_27 VNWC_28 VNWC_29 VNWC_30 VNWC_31 VNWC_32 VNWC_33
+  VNWC_34 VNWC_35 VPW YW0 YW1
** sram464x144IOCDM_L: 4788 flat devices **
XL_IO_I1 BL0_1 BL1_1 BL2_1 BL3_1 BLPRECH D0_1 D1_1 DUMMY[0]_1 DUMMY[1]_1
+  DUMMY[2]_1 DUMMY[3]_1 DUMMY[4]_1 DUMMY[5]_1 DUMMY[6]_1 DUMMY[7]_1 DWL LOG0
+  NACT_CC NBL0_1 NBL1_1 NBL2_1 NBL3_1 NSAE NWCLK NYR0 NYR1 SAO0_1 SAO1_1
+  SAPRECH VDDC_1 VDDCE VDDPE VNWC_1 VDDPE VPW VPW VPW YW0 YW1
+  sram464x144COLM2X2
XL_IO_I10 BL0_10 BL1_10 BL2_10 BL3_10 BLPRECH D0_10 D1_10 DUMMY[0]_10
+  DUMMY[1]_10 DUMMY[2]_10 DUMMY[3]_10 DUMMY[4]_10 DUMMY[5]_10 DUMMY[6]_10
+  DUMMY[7]_10 DWL LOG0 NACT_CC NBL0_10 NBL1_10 NBL2_10 NBL3_10 NSAE NWCLK
+  NYR0 NYR1 SAO0_10 SAO1_10 SAPRECH VDDC_10 VDDCE VDDPE VNWC_10 VDDPE VPW VPW
+  VPW YW0 YW1 sram464x144COLM2X2
XL_IO_I11 BL0_11 BL1_11 BL2_11 BL3_11 BLPRECH D0_11 D1_11 DUMMY[0]_11
+  DUMMY[1]_11 DUMMY[2]_11 DUMMY[3]_11 DUMMY[4]_11 DUMMY[5]_11 DUMMY[6]_11
+  DUMMY[7]_11 DWL LOG0 NACT_CC NBL0_11 NBL1_11 NBL2_11 NBL3_11 NSAE NWCLK
+  NYR0 NYR1 SAO0_11 SAO1_11 SAPRECH VDDC_11 VDDCE VDDPE VNWC_11 VDDPE VPW VPW
+  VPW YW0 YW1 sram464x144COLM2X2
XL_IO_I12 BL0_12 BL1_12 BL2_12 BL3_12 BLPRECH D0_12 D1_12 DUMMY[0]_12
+  DUMMY[1]_12 DUMMY[2]_12 DUMMY[3]_12 DUMMY[4]_12 DUMMY[5]_12 DUMMY[6]_12
+  DUMMY[7]_12 DWL LOG0 NACT_CC NBL0_12 NBL1_12 NBL2_12 NBL3_12 NSAE NWCLK
+  NYR0 NYR1 SAO0_12 SAO1_12 SAPRECH VDDC_12 VDDCE VDDPE VNWC_12 VDDPE VPW VPW
+  VPW YW0 YW1 sram464x144COLM2X2
XL_IO_I13 BL0_13 BL1_13 BL2_13 BL3_13 BLPRECH D0_13 D1_13 DUMMY[0]_13
+  DUMMY[1]_13 DUMMY[2]_13 DUMMY[3]_13 DUMMY[4]_13 DUMMY[5]_13 DUMMY[6]_13
+  DUMMY[7]_13 DWL LOG0 NACT_CC NBL0_13 NBL1_13 NBL2_13 NBL3_13 NSAE NWCLK
+  NYR0 NYR1 SAO0_13 SAO1_13 SAPRECH VDDC_13 VDDCE VDDPE VNWC_13 VDDPE VPW VPW
+  VPW YW0 YW1 sram464x144COLM2X2
XL_IO_I14 BL0_14 BL1_14 BL2_14 BL3_14 BLPRECH D0_14 D1_14 DUMMY[0]_14
+  DUMMY[1]_14 DUMMY[2]_14 DUMMY[3]_14 DUMMY[4]_14 DUMMY[5]_14 DUMMY[6]_14
+  DUMMY[7]_14 DWL LOG0 NACT_CC NBL0_14 NBL1_14 NBL2_14 NBL3_14 NSAE NWCLK
+  NYR0 NYR1 SAO0_14 SAO1_14 SAPRECH VDDC_14 VDDCE VDDPE VNWC_14 VDDPE VPW VPW
+  VPW YW0 YW1 sram464x144COLM2X2
XL_IO_I15 BL0_15 BL1_15 BL2_15 BL3_15 BLPRECH D0_15 D1_15 DUMMY[0]_15
+  DUMMY[1]_15 DUMMY[2]_15 DUMMY[3]_15 DUMMY[4]_15 DUMMY[5]_15 DUMMY[6]_15
+  DUMMY[7]_15 DWL LOG0 NACT_CC NBL0_15 NBL1_15 NBL2_15 NBL3_15 NSAE NWCLK
+  NYR0 NYR1 SAO0_15 SAO1_15 SAPRECH VDDC_15 VDDCE VDDPE VNWC_15 VDDPE VPW VPW
+  VPW YW0 YW1 sram464x144COLM2X2
XL_IO_I16 BL0_16 BL1_16 BL2_16 BL3_16 BLPRECH D0_16 D1_16 DUMMY[0]_16
+  DUMMY[1]_16 DUMMY[2]_16 DUMMY[3]_16 DUMMY[4]_16 DUMMY[5]_16 DUMMY[6]_16
+  DUMMY[7]_16 DWL LOG0 NACT_CC NBL0_16 NBL1_16 NBL2_16 NBL3_16 NSAE NWCLK
+  NYR0 NYR1 SAO0_16 SAO1_16 SAPRECH VDDC_16 VDDCE VDDPE VNWC_16 VDDPE VPW VPW
+  VPW YW0 YW1 sram464x144COLM2X2
XL_IO_I17 BL0_17 BL1_17 BL2_17 BL3_17 BLPRECH D0_17 D1_17 DUMMY[0]_17
+  DUMMY[1]_17 DUMMY[2]_17 DUMMY[3]_17 DUMMY[4]_17 DUMMY[5]_17 DUMMY[6]_17
+  DUMMY[7]_17 DWL LOG0 NACT_CC NBL0_17 NBL1_17 NBL2_17 NBL3_17 NSAE NWCLK
+  NYR0 NYR1 SAO0_17 SAO1_17 SAPRECH VDDC_17 VDDCE VDDPE VNWC_17 VDDPE VPW VPW
+  VPW YW0 YW1 sram464x144COLM2X2
XL_IO_I18 BL0_18 BL1_18 BL2_18 BL3_18 BLPRECH D0_18 D1_18 DUMMY[0]_18
+  DUMMY[1]_18 DUMMY[2]_18 DUMMY[3]_18 DUMMY[4]_18 DUMMY[5]_18 DUMMY[6]_18
+  DUMMY[7]_18 DWL LOG0 NACT_CC NBL0_18 NBL1_18 NBL2_18 NBL3_18 NSAE NWCLK
+  NYR0 NYR1 SAO0_18 SAO1_18 SAPRECH VDDC_18 VDDCE VDDPE VNWC_18 VDDPE VPW VPW
+  VPW YW0 YW1 sram464x144COLM2X2
XL_IO_I19 BL0_19 BL1_19 BL2_19 BL3_19 BLPRECH D0_19 D1_19 DUMMY[0]_19
+  DUMMY[1]_19 DUMMY[2]_19 DUMMY[3]_19 DUMMY[4]_19 DUMMY[5]_19 DUMMY[6]_19
+  DUMMY[7]_19 DWL LOG0 NACT_CC NBL0_19 NBL1_19 NBL2_19 NBL3_19 NSAE NWCLK
+  NYR0 NYR1 SAO0_19 SAO1_19 SAPRECH VDDC_19 VDDCE VDDPE VNWC_19 VDDPE VPW VPW
+  VPW YW0 YW1 sram464x144COLM2X2
XL_IO_I2 BL0_2 BL1_2 BL2_2 BL3_2 BLPRECH D0_2 D1_2 DUMMY[0]_2 DUMMY[1]_2
+  DUMMY[2]_2 DUMMY[3]_2 DUMMY[4]_2 DUMMY[5]_2 DUMMY[6]_2 DUMMY[7]_2 DWL LOG0
+  NACT_CC NBL0_2 NBL1_2 NBL2_2 NBL3_2 NSAE NWCLK NYR0 NYR1 SAO0_2 SAO1_2
+  SAPRECH VDDC_2 VDDCE VDDPE VNWC_2 VDDPE VPW VPW VPW YW0 YW1
+  sram464x144COLM2X2
XL_IO_I20 BL0_20 BL1_20 BL2_20 BL3_20 BLPRECH D0_20 D1_20 DUMMY[0]_20
+  DUMMY[1]_20 DUMMY[2]_20 DUMMY[3]_20 DUMMY[4]_20 DUMMY[5]_20 DUMMY[6]_20
+  DUMMY[7]_20 DWL LOG0 NACT_CC NBL0_20 NBL1_20 NBL2_20 NBL3_20 NSAE NWCLK
+  NYR0 NYR1 SAO0_20 SAO1_20 SAPRECH VDDC_20 VDDCE VDDPE VNWC_20 VDDPE VPW VPW
+  VPW YW0 YW1 sram464x144COLM2X2
XL_IO_I21 BL0_21 BL1_21 BL2_21 BL3_21 BLPRECH D0_21 D1_21 DUMMY[0]_21
+  DUMMY[1]_21 DUMMY[2]_21 DUMMY[3]_21 DUMMY[4]_21 DUMMY[5]_21 DUMMY[6]_21
+  DUMMY[7]_21 DWL LOG0 NACT_CC NBL0_21 NBL1_21 NBL2_21 NBL3_21 NSAE NWCLK
+  NYR0 NYR1 SAO0_21 SAO1_21 SAPRECH VDDC_21 VDDCE VDDPE VNWC_21 VDDPE VPW VPW
+  VPW YW0 YW1 sram464x144COLM2X2
XL_IO_I22 BL0_22 BL1_22 BL2_22 BL3_22 BLPRECH D0_22 D1_22 DUMMY[0]_22
+  DUMMY[1]_22 DUMMY[2]_22 DUMMY[3]_22 DUMMY[4]_22 DUMMY[5]_22 DUMMY[6]_22
+  DUMMY[7]_22 DWL LOG0 NACT_CC NBL0_22 NBL1_22 NBL2_22 NBL3_22 NSAE NWCLK
+  NYR0 NYR1 SAO0_22 SAO1_22 SAPRECH VDDC_22 VDDCE VDDPE VNWC_22 VDDPE VPW VPW
+  VPW YW0 YW1 sram464x144COLM2X2
XL_IO_I23 BL0_23 BL1_23 BL2_23 BL3_23 BLPRECH D0_23 D1_23 DUMMY[0]_23
+  DUMMY[1]_23 DUMMY[2]_23 DUMMY[3]_23 DUMMY[4]_23 DUMMY[5]_23 DUMMY[6]_23
+  DUMMY[7]_23 DWL LOG0 NACT_CC NBL0_23 NBL1_23 NBL2_23 NBL3_23 NSAE NWCLK
+  NYR0 NYR1 SAO0_23 SAO1_23 SAPRECH VDDC_23 VDDCE VDDPE VNWC_23 VDDPE VPW VPW
+  VPW YW0 YW1 sram464x144COLM2X2
XL_IO_I24 BL0_24 BL1_24 BL2_24 BL3_24 BLPRECH D0_24 D1_24 DUMMY[0]_24
+  DUMMY[1]_24 DUMMY[2]_24 DUMMY[3]_24 DUMMY[4]_24 DUMMY[5]_24 DUMMY[6]_24
+  DUMMY[7]_24 DWL LOG0 NACT_CC NBL0_24 NBL1_24 NBL2_24 NBL3_24 NSAE NWCLK
+  NYR0 NYR1 SAO0_24 SAO1_24 SAPRECH VDDC_24 VDDCE VDDPE VNWC_24 VDDPE VPW VPW
+  VPW YW0 YW1 sram464x144COLM2X2
XL_IO_I25 BL0_25 BL1_25 BL2_25 BL3_25 BLPRECH D0_25 D1_25 DUMMY[0]_25
+  DUMMY[1]_25 DUMMY[2]_25 DUMMY[3]_25 DUMMY[4]_25 DUMMY[5]_25 DUMMY[6]_25
+  DUMMY[7]_25 DWL LOG0 NACT_CC NBL0_25 NBL1_25 NBL2_25 NBL3_25 NSAE NWCLK
+  NYR0 NYR1 SAO0_25 SAO1_25 SAPRECH VDDC_25 VDDCE VDDPE VNWC_25 VDDPE VPW VPW
+  VPW YW0 YW1 sram464x144COLM2X2
XL_IO_I26 BL0_26 BL1_26 BL2_26 BL3_26 BLPRECH D0_26 D1_26 DUMMY[0]_26
+  DUMMY[1]_26 DUMMY[2]_26 DUMMY[3]_26 DUMMY[4]_26 DUMMY[5]_26 DUMMY[6]_26
+  DUMMY[7]_26 DWL LOG0 NACT_CC NBL0_26 NBL1_26 NBL2_26 NBL3_26 NSAE NWCLK
+  NYR0 NYR1 SAO0_26 SAO1_26 SAPRECH VDDC_26 VDDCE VDDPE VNWC_26 VDDPE VPW VPW
+  VPW YW0 YW1 sram464x144COLM2X2
XL_IO_I27 BL0_27 BL1_27 BL2_27 BL3_27 BLPRECH D0_27 D1_27 DUMMY[0]_27
+  DUMMY[1]_27 DUMMY[2]_27 DUMMY[3]_27 DUMMY[4]_27 DUMMY[5]_27 DUMMY[6]_27
+  DUMMY[7]_27 DWL LOG0 NACT_CC NBL0_27 NBL1_27 NBL2_27 NBL3_27 NSAE NWCLK
+  NYR0 NYR1 SAO0_27 SAO1_27 SAPRECH VDDC_27 VDDCE VDDPE VNWC_27 VDDPE VPW VPW
+  VPW YW0 YW1 sram464x144COLM2X2
XL_IO_I28 BL0_28 BL1_28 BL2_28 BL3_28 BLPRECH D0_28 D1_28 DUMMY[0]_28
+  DUMMY[1]_28 DUMMY[2]_28 DUMMY[3]_28 DUMMY[4]_28 DUMMY[5]_28 DUMMY[6]_28
+  DUMMY[7]_28 DWL LOG0 NACT_CC NBL0_28 NBL1_28 NBL2_28 NBL3_28 NSAE NWCLK
+  NYR0 NYR1 SAO0_28 SAO1_28 SAPRECH VDDC_28 VDDCE VDDPE VNWC_28 VDDPE VPW VPW
+  VPW YW0 YW1 sram464x144COLM2X2
XL_IO_I29 BL0_29 BL1_29 BL2_29 BL3_29 BLPRECH D0_29 D1_29 DUMMY[0]_29
+  DUMMY[1]_29 DUMMY[2]_29 DUMMY[3]_29 DUMMY[4]_29 DUMMY[5]_29 DUMMY[6]_29
+  DUMMY[7]_29 DWL LOG0 NACT_CC NBL0_29 NBL1_29 NBL2_29 NBL3_29 NSAE NWCLK
+  NYR0 NYR1 SAO0_29 SAO1_29 SAPRECH VDDC_29 VDDCE VDDPE VNWC_29 VDDPE VPW VPW
+  VPW YW0 YW1 sram464x144COLM2X2
XL_IO_I3 BL0_3 BL1_3 BL2_3 BL3_3 BLPRECH D0_3 D1_3 DUMMY[0]_3 DUMMY[1]_3
+  DUMMY[2]_3 DUMMY[3]_3 DUMMY[4]_3 DUMMY[5]_3 DUMMY[6]_3 DUMMY[7]_3 DWL LOG0
+  NACT_CC NBL0_3 NBL1_3 NBL2_3 NBL3_3 NSAE NWCLK NYR0 NYR1 SAO0_3 SAO1_3
+  SAPRECH VDDC_3 VDDCE VDDPE VNWC_3 VDDPE VPW VPW VPW YW0 YW1
+  sram464x144COLM2X2
XL_IO_I30 BL0_30 BL1_30 BL2_30 BL3_30 BLPRECH D0_30 D1_30 DUMMY[0]_30
+  DUMMY[1]_30 DUMMY[2]_30 DUMMY[3]_30 DUMMY[4]_30 DUMMY[5]_30 DUMMY[6]_30
+  DUMMY[7]_30 DWL LOG0 NACT_CC NBL0_30 NBL1_30 NBL2_30 NBL3_30 NSAE NWCLK
+  NYR0 NYR1 SAO0_30 SAO1_30 SAPRECH VDDC_30 VDDCE VDDPE VNWC_30 VDDPE VPW VPW
+  VPW YW0 YW1 sram464x144COLM2X2
XL_IO_I31 BL0_31 BL1_31 BL2_31 BL3_31 BLPRECH D0_31 D1_31 DUMMY[0]_31
+  DUMMY[1]_31 DUMMY[2]_31 DUMMY[3]_31 DUMMY[4]_31 DUMMY[5]_31 DUMMY[6]_31
+  DUMMY[7]_31 DWL LOG0 NACT_CC NBL0_31 NBL1_31 NBL2_31 NBL3_31 NSAE NWCLK
+  NYR0 NYR1 SAO0_31 SAO1_31 SAPRECH VDDC_31 VDDCE VDDPE VNWC_31 VDDPE VPW VPW
+  VPW YW0 YW1 sram464x144COLM2X2
XL_IO_I32 BL0_32 BL1_32 BL2_32 BL3_32 BLPRECH D0_32 D1_32 DUMMY[0]_32
+  DUMMY[1]_32 DUMMY[2]_32 DUMMY[3]_32 DUMMY[4]_32 DUMMY[5]_32 DUMMY[6]_32
+  DUMMY[7]_32 DWL LOG0 NACT_CC NBL0_32 NBL1_32 NBL2_32 NBL3_32 NSAE NWCLK
+  NYR0 NYR1 SAO0_32 SAO1_32 SAPRECH VDDC_32 VDDCE VDDPE VNWC_32 VDDPE VPW VPW
+  VPW YW0 YW1 sram464x144COLM2X2
XL_IO_I33 BL0_33 BL1_33 BL2_33 BL3_33 BLPRECH D0_33 D1_33 DUMMY[0]_33
+  DUMMY[1]_33 DUMMY[2]_33 DUMMY[3]_33 DUMMY[4]_33 DUMMY[5]_33 DUMMY[6]_33
+  DUMMY[7]_33 DWL LOG0 NACT_CC NBL0_33 NBL1_33 NBL2_33 NBL3_33 NSAE NWCLK
+  NYR0 NYR1 SAO0_33 SAO1_33 SAPRECH VDDC_33 VDDCE VDDPE VNWC_33 VDDPE VPW VPW
+  VPW YW0 YW1 sram464x144COLM2X2
XL_IO_I34 BL0_34 BL1_34 BL2_34 BL3_34 BLPRECH D0_34 D1_34 DUMMY[0]_34
+  DUMMY[1]_34 DUMMY[2]_34 DUMMY[3]_34 DUMMY[4]_34 DUMMY[5]_34 DUMMY[6]_34
+  DUMMY[7]_34 DWL LOG0 NACT_CC NBL0_34 NBL1_34 NBL2_34 NBL3_34 NSAE NWCLK
+  NYR0 NYR1 SAO0_34 SAO1_34 SAPRECH VDDC_34 VDDCE VDDPE VNWC_34 VDDPE VPW VPW
+  VPW YW0 YW1 sram464x144COLM2X2
XL_IO_I4 BL0_4 BL1_4 BL2_4 BL3_4 BLPRECH D0_4 D1_4 DUMMY[0]_4 DUMMY[1]_4
+  DUMMY[2]_4 DUMMY[3]_4 DUMMY[4]_4 DUMMY[5]_4 DUMMY[6]_4 DUMMY[7]_4 DWL LOG0
+  NACT_CC NBL0_4 NBL1_4 NBL2_4 NBL3_4 NSAE NWCLK NYR0 NYR1 SAO0_4 SAO1_4
+  SAPRECH VDDC_4 VDDCE VDDPE VNWC_4 VDDPE VPW VPW VPW YW0 YW1
+  sram464x144COLM2X2
XL_IO_I5 BL0_5 BL1_5 BL2_5 BL3_5 BLPRECH D0_5 D1_5 DUMMY[0]_5 DUMMY[1]_5
+  DUMMY[2]_5 DUMMY[3]_5 DUMMY[4]_5 DUMMY[5]_5 DUMMY[6]_5 DUMMY[7]_5 DWL LOG0
+  NACT_CC NBL0_5 NBL1_5 NBL2_5 NBL3_5 NSAE NWCLK NYR0 NYR1 SAO0_5 SAO1_5
+  SAPRECH VDDC_5 VDDCE VDDPE VNWC_5 VDDPE VPW VPW VPW YW0 YW1
+  sram464x144COLM2X2
XL_IO_I6 BL0_6 BL1_6 BL2_6 BL3_6 BLPRECH D0_6 D1_6 DUMMY[0]_6 DUMMY[1]_6
+  DUMMY[2]_6 DUMMY[3]_6 DUMMY[4]_6 DUMMY[5]_6 DUMMY[6]_6 DUMMY[7]_6 DWL LOG0
+  NACT_CC NBL0_6 NBL1_6 NBL2_6 NBL3_6 NSAE NWCLK NYR0 NYR1 SAO0_6 SAO1_6
+  SAPRECH VDDC_6 VDDCE VDDPE VNWC_6 VDDPE VPW VPW VPW YW0 YW1
+  sram464x144COLM2X2
XL_IO_I7 BL0_7 BL1_7 BL2_7 BL3_7 BLPRECH D0_7 D1_7 DUMMY[0]_7 DUMMY[1]_7
+  DUMMY[2]_7 DUMMY[3]_7 DUMMY[4]_7 DUMMY[5]_7 DUMMY[6]_7 DUMMY[7]_7 DWL LOG0
+  NACT_CC NBL0_7 NBL1_7 NBL2_7 NBL3_7 NSAE NWCLK NYR0 NYR1 SAO0_7 SAO1_7
+  SAPRECH VDDC_7 VDDCE VDDPE VNWC_7 VDDPE VPW VPW VPW YW0 YW1
+  sram464x144COLM2X2
XL_IO_I8 BL0_8 BL1_8 BL2_8 BL3_8 BLPRECH D0_8 D1_8 DUMMY[0]_8 DUMMY[1]_8
+  DUMMY[2]_8 DUMMY[3]_8 DUMMY[4]_8 DUMMY[5]_8 DUMMY[6]_8 DUMMY[7]_8 DWL LOG0
+  NACT_CC NBL0_8 NBL1_8 NBL2_8 NBL3_8 NSAE NWCLK NYR0 NYR1 SAO0_8 SAO1_8
+  SAPRECH VDDC_8 VDDCE VDDPE VNWC_8 VDDPE VPW VPW VPW YW0 YW1
+  sram464x144COLM2X2
XL_IO_I9 BL0_9 BL1_9 BL2_9 BL3_9 BLPRECH D0_9 D1_9 DUMMY[0]_9 DUMMY[1]_9
+  DUMMY[2]_9 DUMMY[3]_9 DUMMY[4]_9 DUMMY[5]_9 DUMMY[6]_9 DUMMY[7]_9 DWL LOG0
+  NACT_CC NBL0_9 NBL1_9 NBL2_9 NBL3_9 NSAE NWCLK NYR0 NYR1 SAO0_9 SAO1_9
+  SAPRECH VDDC_9 VDDCE VDDPE VNWC_9 VDDPE VPW VPW VPW YW0 YW1
+  sram464x144COLM2X2
XL_IO_L BL0_0 BL1_0 BL2_0 BL3_0 BLPRECH D0_0 D1_0 DUMMY[0]_0 DUMMY[1]_0
+  DUMMY[2]_0 DUMMY[3]_0 DUMMY[4]_0 DUMMY[5]_0 DUMMY[6]_0 DUMMY[7]_0 DWL LOG0
+  NACT_CC NBL0_0 NBL1_0 NBL2_0 NBL3_0 NSAE NWCLK NYR0 NYR1 SAO0_0 SAO1_0
+  SAPRECH VDDC_0 VDDCE VDDPE VNWC_0 VDDPE VPW VPW VPW YW0 YW1
+  sram464x144COLM2X2
XL_IO_R BL0_35 BL1_35 BL2_35 BL3_35 BLPRECH D0_35 D1_35 DUMMY[0]_35
+  DUMMY[1]_35 DUMMY[2]_35 DUMMY[3]_35 DUMMY[4]_35 DUMMY[5]_35 DUMMY[6]_35
+  DUMMY[7]_35 DWL LOG0 NACT_CC NBL0_35 NBL1_35 NBL2_35 NBL3_35 NSAE NWCLK
+  NYR0 NYR1 SAO0_35 SAO1_35 SAPRECH VDDC_35 VDDCE VDDPE VNWC_35 VDDPE VPW VPW
+  VPW YW0 YW1 sram464x144COLM2X2
.ENDS sram464x144IOCDM_L
****
.SUBCKT sram464x144FLCOLM2 BLPRECH DUMMY DWL LOG0 NACT_CC NSAE NWCLK NYR0 NYR1
+  SAPRECH VDDCE VDDPE VNWC VNWP VPW VSS VSSE YW0 YW1
** sram464x144FLCOLM2: 2 flat devices **
X_MXN0 LOG0 LOG0 LOG0 VPW N11LL_CKT W=0.155U L=0.04U
X_MXN3 LOG0 LOG0 LOG0 VPW N11LL_CKT W=0.62U L=0.085U
.ENDS sram464x144FLCOLM2
****
.SUBCKT sram464x144CCHD4_CORNER VDDC VNWC VNWP VPW VSSE
** sram464x144CCHD4_CORNER: 3 flat devices **
X_MXN0 VSSE NET17 NET16 VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MXN2 VPW NET21 NET20 VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MXN3 VPW NET25 VPW VPW dslnfetpd_ckt W=0.142U L=0.055U
.ENDS sram464x144CCHD4_CORNER
****
.SUBCKT sram464x144IOEDGE BLPRECH DUM_SEL_D DUM_SEL_TD DWL LOG0_0 LOG0_1
+  NACT_CC NSAE NWCLK NYR0 NYR1 SAPRECH VDDC VDDCE VDDPE VNWC VPW VSS YW0 YW1
** sram464x144IOEDGE: 5 flat devices **
XCOLM_EDGE BLPRECH LOG0_0 DWL LOG0_1 NACT_CC NSAE NWCLK NYR0 NYR1 SAPRECH
+  VDDCE VDDPE VNWC VDDPE VPW VSS VPW YW0 YW1 sram464x144FLCOLM2
XIO_CORNER VDDC VNWC VDDPE VPW VPW sram464x144CCHD4_CORNER
.ENDS sram464x144IOEDGE
****
.SUBCKT sram464x144RDM2X2 D0 D1 DUM_SEL_D_L DUM_SEL_D_R DUM_SEL_TD_L
+  DUM_SEL_TD_R Q0 Q1 SAO0 SAO1 TD0 TD1 TWEN0 TWEN1 VDDCE VDDPE VNWP VPW VSS
+  VSSE WEN0 WEN1 WENY0 WENY1
** sram464x144RDM2X2: 4 flat devices **
X_M_rd0.I149.MXNA1 Q0 SAO0 VSS VPW N11LL_CKT W=2.04U L=0.04U
X_M_rd0.I149.MXPA1 Q0 SAO0 VDDPE VNWP P11LL_CKT W=4.14U L=0.04U
X_M_rd1.I149.MXNA1 Q1 SAO1 VSS VPW N11LL_CKT W=2.04U L=0.04U
X_M_rd1.I149.MXPA1 Q1 SAO1 VDDPE VNWP P11LL_CKT W=4.14U L=0.04U
.ENDS sram464x144RDM2X2
****
.SUBCKT sram464x144IO_RDM_L D0_0 D0_1 D0_2 D0_3 D0_4 D0_5 D0_6 D0_7 D0_8 D0_9
+  D0_10 D0_11 D0_12 D0_13 D0_14 D0_15 D0_16 D0_17 D0_18 D0_19 D0_20 D0_21
+  D0_22 D0_23 D0_24 D0_25 D0_26 D0_27 D0_28 D0_29 D0_30 D0_31 D0_32 D0_33
+  D0_34 D0_35 D1_0 D1_1 D1_2 D1_3 D1_4 D1_5 D1_6 D1_7 D1_8 D1_9 D1_10 D1_11
+  D1_12 D1_13 D1_14 D1_15 D1_16 D1_17 D1_18 D1_19 D1_20 D1_21 D1_22 D1_23
+  D1_24 D1_25 D1_26 D1_27 D1_28 D1_29 D1_30 D1_31 D1_32 D1_33 D1_34 D1_35
+  DUM_SEL_D_L DUM_SEL_D_R DUM_SEL_TD_L DUM_SEL_TD_R Q0_0 Q0_1 Q0_2 Q0_3 Q0_4
+  Q0_5 Q0_6 Q0_7 Q0_8 Q0_9 Q0_10 Q0_11 Q0_12 Q0_13 Q0_14 Q0_15 Q0_16 Q0_17
+  Q0_18 Q0_19 Q0_20 Q0_21 Q0_22 Q0_23 Q0_24 Q0_25 Q0_26 Q0_27 Q0_28 Q0_29
+  Q0_30 Q0_31 Q0_32 Q0_33 Q0_34 Q0_35 Q1_0 Q1_1 Q1_2 Q1_3 Q1_4 Q1_5 Q1_6 Q1_7
+  Q1_8 Q1_9 Q1_10 Q1_11 Q1_12 Q1_13 Q1_14 Q1_15 Q1_16 Q1_17 Q1_18 Q1_19 Q1_20
+  Q1_21 Q1_22 Q1_23 Q1_24 Q1_25 Q1_26 Q1_27 Q1_28 Q1_29 Q1_30 Q1_31 Q1_32
+  Q1_33 Q1_34 Q1_35 SAO0_0 SAO0_1 SAO0_2 SAO0_3 SAO0_4 SAO0_5 SAO0_6 SAO0_7
+  SAO0_8 SAO0_9 SAO0_10 SAO0_11 SAO0_12 SAO0_13 SAO0_14 SAO0_15 SAO0_16
+  SAO0_17 SAO0_18 SAO0_19 SAO0_20 SAO0_21 SAO0_22 SAO0_23 SAO0_24 SAO0_25
+  SAO0_26 SAO0_27 SAO0_28 SAO0_29 SAO0_30 SAO0_31 SAO0_32 SAO0_33 SAO0_34
+  SAO0_35 SAO1_0 SAO1_1 SAO1_2 SAO1_3 SAO1_4 SAO1_5 SAO1_6 SAO1_7 SAO1_8
+  SAO1_9 SAO1_10 SAO1_11 SAO1_12 SAO1_13 SAO1_14 SAO1_15 SAO1_16 SAO1_17
+  SAO1_18 SAO1_19 SAO1_20 SAO1_21 SAO1_22 SAO1_23 SAO1_24 SAO1_25 SAO1_26
+  SAO1_27 SAO1_28 SAO1_29 SAO1_30 SAO1_31 SAO1_32 SAO1_33 SAO1_34 SAO1_35
+  TD0_0 TD0_1 TD0_2 TD0_3 TD0_4 TD0_5 TD0_6 TD0_7 TD0_8 TD0_9 TD0_10 TD0_11
+  TD0_12 TD0_13 TD0_14 TD0_15 TD0_16 TD0_17 TD0_18 TD0_19 TD0_20 TD0_21
+  TD0_22 TD0_23 TD0_24 TD0_25 TD0_26 TD0_27 TD0_28 TD0_29 TD0_30 TD0_31
+  TD0_32 TD0_33 TD0_34 TD0_35 TD1_0 TD1_1 TD1_2 TD1_3 TD1_4 TD1_5 TD1_6 TD1_7
+  TD1_8 TD1_9 TD1_10 TD1_11 TD1_12 TD1_13 TD1_14 TD1_15 TD1_16 TD1_17 TD1_18
+  TD1_19 TD1_20 TD1_21 TD1_22 TD1_23 TD1_24 TD1_25 TD1_26 TD1_27 TD1_28
+  TD1_29 TD1_30 TD1_31 TD1_32 TD1_33 TD1_34 TD1_35 TWEN0_0 TWEN0_1 TWEN0_2
+  TWEN0_3 TWEN0_4 TWEN0_5 TWEN0_6 TWEN0_7 TWEN0_8 TWEN0_9 TWEN0_10 TWEN0_11
+  TWEN0_12 TWEN0_13 TWEN0_14 TWEN0_15 TWEN0_16 TWEN0_17 TWEN0_18 TWEN0_19
+  TWEN0_20 TWEN0_21 TWEN0_22 TWEN0_23 TWEN0_24 TWEN0_25 TWEN0_26 TWEN0_27
+  TWEN0_28 TWEN0_29 TWEN0_30 TWEN0_31 TWEN0_32 TWEN0_33 TWEN0_34 TWEN0_35
+  TWEN1_0 TWEN1_1 TWEN1_2 TWEN1_3 TWEN1_4 TWEN1_5 TWEN1_6 TWEN1_7 TWEN1_8
+  TWEN1_9 TWEN1_10 TWEN1_11 TWEN1_12 TWEN1_13 TWEN1_14 TWEN1_15 TWEN1_16
+  TWEN1_17 TWEN1_18 TWEN1_19 TWEN1_20 TWEN1_21 TWEN1_22 TWEN1_23 TWEN1_24
+  TWEN1_25 TWEN1_26 TWEN1_27 TWEN1_28 TWEN1_29 TWEN1_30 TWEN1_31 TWEN1_32
+  TWEN1_33 TWEN1_34 TWEN1_35 VDDCE_0 VDDCE_1 VDDCE_2 VDDCE_3 VDDCE_4 VDDCE_5
+  VDDCE_6 VDDCE_7 VDDCE_8 VDDCE_9 VDDCE_10 VDDCE_11 VDDCE_12 VDDCE_13
+  VDDCE_14 VDDCE_15 VDDCE_16 VDDCE_17 VDDCE_18 VDDCE_19 VDDCE_20 VDDCE_21
+  VDDCE_22 VDDCE_23 VDDCE_24 VDDCE_25 VDDCE_26 VDDCE_27 VDDCE_28 VDDCE_29
+  VDDCE_30 VDDCE_31 VDDCE_32 VDDCE_33 VDDCE_34 VDDCE_35 VDDPE_0 VDDPE_1
+  VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8 VDDPE_9 VDDPE_10
+  VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16 VDDPE_17 VDDPE_18
+  VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24 VDDPE_25 VDDPE_26
+  VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32 VDDPE_33 VDDPE_34
+  VDDPE_35 VNWP_0 VNWP_1 VNWP_2 VNWP_3 VNWP_4 VNWP_5 VNWP_6 VNWP_7 VNWP_8
+  VNWP_9 VNWP_10 VNWP_11 VNWP_12 VNWP_13 VNWP_14 VNWP_15 VNWP_16 VNWP_17
+  VNWP_18 VNWP_19 VNWP_20 VNWP_21 VNWP_22 VNWP_23 VNWP_24 VNWP_25 VNWP_26
+  VNWP_27 VNWP_28 VNWP_29 VNWP_30 VNWP_31 VNWP_32 VNWP_33 VNWP_34 VNWP_35
+  VPW_0 VPW_1 VPW_2 VPW_3 VPW_4 VPW_5 VPW_6 VPW_7 VPW_8 VPW_9 VPW_10 VPW_11
+  VPW_12 VPW_13 VPW_14 VPW_15 VPW_16 VPW_17 VPW_18 VPW_19 VPW_20 VPW_21
+  VPW_22 VPW_23 VPW_24 VPW_25 VPW_26 VPW_27 VPW_28 VPW_29 VPW_30 VPW_31
+  VPW_32 VPW_33 VPW_34 VPW_35 VSS_0 VSS_1 VSS_2 VSS_3 VSS_4 VSS_5 VSS_6 VSS_7
+  VSS_8 VSS_9 VSS_10 VSS_11 VSS_12 VSS_13 VSS_14 VSS_15 VSS_16 VSS_17 VSS_18
+  VSS_19 VSS_20 VSS_21 VSS_22 VSS_23 VSS_24 VSS_25 VSS_26 VSS_27 VSS_28
+  VSS_29 VSS_30 VSS_31 VSS_32 VSS_33 VSS_34 VSS_35 WEN0_0 WEN0_1 WEN0_2
+  WEN0_3 WEN0_4 WEN0_5 WEN0_6 WEN0_7 WEN0_8 WEN0_9 WEN0_10 WEN0_11 WEN0_12
+  WEN0_13 WEN0_14 WEN0_15 WEN0_16 WEN0_17 WEN0_18 WEN0_19 WEN0_20 WEN0_21
+  WEN0_22 WEN0_23 WEN0_24 WEN0_25 WEN0_26 WEN0_27 WEN0_28 WEN0_29 WEN0_30
+  WEN0_31 WEN0_32 WEN0_33 WEN0_34 WEN0_35 WEN1_0 WEN1_1 WEN1_2 WEN1_3 WEN1_4
+  WEN1_5 WEN1_6 WEN1_7 WEN1_8 WEN1_9 WEN1_10 WEN1_11 WEN1_12 WEN1_13 WEN1_14
+  WEN1_15 WEN1_16 WEN1_17 WEN1_18 WEN1_19 WEN1_20 WEN1_21 WEN1_22 WEN1_23
+  WEN1_24 WEN1_25 WEN1_26 WEN1_27 WEN1_28 WEN1_29 WEN1_30 WEN1_31 WEN1_32
+  WEN1_33 WEN1_34 WEN1_35 WENY0_0 WENY0_1 WENY0_2 WENY0_3 WENY0_4 WENY0_5
+  WENY0_6 WENY0_7 WENY0_8 WENY0_9 WENY0_10 WENY0_11 WENY0_12 WENY0_13
+  WENY0_14 WENY0_15 WENY0_16 WENY0_17 WENY0_18 WENY0_19 WENY0_20 WENY0_21
+  WENY0_22 WENY0_23 WENY0_24 WENY0_25 WENY0_26 WENY0_27 WENY0_28 WENY0_29
+  WENY0_30 WENY0_31 WENY0_32 WENY0_33 WENY0_34 WENY0_35 WENY1_0 WENY1_1
+  WENY1_2 WENY1_3 WENY1_4 WENY1_5 WENY1_6 WENY1_7 WENY1_8 WENY1_9 WENY1_10
+  WENY1_11 WENY1_12 WENY1_13 WENY1_14 WENY1_15 WENY1_16 WENY1_17 WENY1_18
+  WENY1_19 WENY1_20 WENY1_21 WENY1_22 WENY1_23 WENY1_24 WENY1_25 WENY1_26
+  WENY1_27 WENY1_28 WENY1_29 WENY1_30 WENY1_31 WENY1_32 WENY1_33 WENY1_34
+  WENY1_35
** sram464x144IO_RDM_L: 144 flat devices **
XL_RDM_1 D0_1 D1_1 DUM_SEL_D_R_68 DUM_SEL_D_R_72 DUM_SEL_TD_R_70
+  DUM_SEL_TD_R_74 Q0_1 Q1_1 SAO0_1 SAO1_1 TD0_1 TD1_1 TWEN0_1 TWEN1_1 VDDCE_1
+  VDDPE_1 VNWP_1 VPW_1 VSS_1 VSS_1 WEN0_1 WEN1_1 WENY0_1 WENY1_1
+  sram464x144RDM2X2
XL_RDM_10 D0_10 D1_10 DUM_SEL_D_L_4 DUM_SEL_D_R_0 DUM_SEL_TD_L_6
+  DUM_SEL_TD_R_2 Q0_10 Q1_10 SAO0_10 SAO1_10 TD0_10 TD1_10 TWEN0_10 TWEN1_10
+  VDDCE_10 VDDPE_10 VNWP_10 VPW_10 VSS_10 VSS_10 WEN0_10 WEN1_10 WENY0_10
+  WENY1_10 sram464x144RDM2X2
XL_RDM_11 D0_11 D1_11 DUM_SEL_D_R_0 DUM_SEL_D_R_8 DUM_SEL_TD_R_2
+  DUM_SEL_TD_R_10 Q0_11 Q1_11 SAO0_11 SAO1_11 TD0_11 TD1_11 TWEN0_11 TWEN1_11
+  VDDCE_11 VDDPE_11 VNWP_11 VPW_11 VSS_11 VSS_11 WEN0_11 WEN1_11 WENY0_11
+  WENY1_11 sram464x144RDM2X2
XL_RDM_12 D0_12 D1_12 DUM_SEL_D_R_8 DUM_SEL_D_R_20 DUM_SEL_TD_R_10
+  DUM_SEL_TD_R_22 Q0_12 Q1_12 SAO0_12 SAO1_12 TD0_12 TD1_12 TWEN0_12 TWEN1_12
+  VDDCE_12 VDDPE_12 VNWP_12 VPW_12 VSS_12 VSS_12 WEN0_12 WEN1_12 WENY0_12
+  WENY1_12 sram464x144RDM2X2
XL_RDM_13 D0_13 D1_13 DUM_SEL_D_R_20 DUM_SEL_D_R_28 DUM_SEL_TD_R_22
+  DUM_SEL_TD_R_30 Q0_13 Q1_13 SAO0_13 SAO1_13 TD0_13 TD1_13 TWEN0_13 TWEN1_13
+  VDDCE_13 VDDPE_13 VNWP_13 VPW_13 VSS_13 VSS_13 WEN0_13 WEN1_13 WENY0_13
+  WENY1_13 sram464x144RDM2X2
XL_RDM_14 D0_14 D1_14 DUM_SEL_D_R_28 DUM_SEL_D_R_36 DUM_SEL_TD_R_30
+  DUM_SEL_TD_R_38 Q0_14 Q1_14 SAO0_14 SAO1_14 TD0_14 TD1_14 TWEN0_14 TWEN1_14
+  VDDCE_14 VDDPE_14 VNWP_14 VPW_14 VSS_14 VSS_14 WEN0_14 WEN1_14 WENY0_14
+  WENY1_14 sram464x144RDM2X2
XL_RDM_15 D0_15 D1_15 DUM_SEL_D_R_36 DUM_SEL_D_R_44 DUM_SEL_TD_R_38
+  DUM_SEL_TD_R_46 Q0_15 Q1_15 SAO0_15 SAO1_15 TD0_15 TD1_15 TWEN0_15 TWEN1_15
+  VDDCE_15 VDDPE_15 VNWP_15 VPW_15 VSS_15 VSS_15 WEN0_15 WEN1_15 WENY0_15
+  WENY1_15 sram464x144RDM2X2
XL_RDM_16 D0_16 D1_16 DUM_SEL_D_R_44 DUM_SEL_D_R_52 DUM_SEL_TD_R_46
+  DUM_SEL_TD_R_54 Q0_16 Q1_16 SAO0_16 SAO1_16 TD0_16 TD1_16 TWEN0_16 TWEN1_16
+  VDDCE_16 VDDPE_16 VNWP_16 VPW_16 VSS_16 VSS_16 WEN0_16 WEN1_16 WENY0_16
+  WENY1_16 sram464x144RDM2X2
XL_RDM_17 D0_17 D1_17 DUM_SEL_D_R_52 DUM_SEL_D_R_56 DUM_SEL_TD_R_54
+  DUM_SEL_TD_R_58 Q0_17 Q1_17 SAO0_17 SAO1_17 TD0_17 TD1_17 TWEN0_17 TWEN1_17
+  VDDCE_17 VDDPE_17 VNWP_17 VPW_17 VSS_17 VSS_17 WEN0_17 WEN1_17 WENY0_17
+  WENY1_17 sram464x144RDM2X2
XL_RDM_18 D0_18 D1_18 DUM_SEL_D_R_56 DUM_SEL_D_R_60 DUM_SEL_TD_R_58
+  DUM_SEL_TD_R_62 Q0_18 Q1_18 SAO0_18 SAO1_18 TD0_18 TD1_18 TWEN0_18 TWEN1_18
+  VDDCE_18 VDDPE_18 VNWP_18 VPW_18 VSS_18 VSS_18 WEN0_18 WEN1_18 WENY0_18
+  WENY1_18 sram464x144RDM2X2
XL_RDM_19 D0_19 D1_19 DUM_SEL_D_R_60 DUM_SEL_D_R_64 DUM_SEL_TD_R_62
+  DUM_SEL_TD_R_66 Q0_19 Q1_19 SAO0_19 SAO1_19 TD0_19 TD1_19 TWEN0_19 TWEN1_19
+  VDDCE_19 VDDPE_19 VNWP_19 VPW_19 VSS_19 VSS_19 WEN0_19 WEN1_19 WENY0_19
+  WENY1_19 sram464x144RDM2X2
XL_RDM_2 D0_2 D1_2 DUM_SEL_D_R_72 DUM_SEL_D_R_76 DUM_SEL_TD_R_74
+  DUM_SEL_TD_R_78 Q0_2 Q1_2 SAO0_2 SAO1_2 TD0_2 TD1_2 TWEN0_2 TWEN1_2 VDDCE_2
+  VDDPE_2 VNWP_2 VPW_2 VSS_2 VSS_2 WEN0_2 WEN1_2 WENY0_2 WENY1_2
+  sram464x144RDM2X2
XL_RDM_20 D0_20 D1_20 DUM_SEL_D_R_64 DUM_SEL_D_R_104 DUM_SEL_TD_R_66
+  DUM_SEL_TD_R_106 Q0_20 Q1_20 SAO0_20 SAO1_20 TD0_20 TD1_20 TWEN0_20
+  TWEN1_20 VDDCE_20 VDDPE_20 VNWP_20 VPW_20 VSS_20 VSS_20 WEN0_20 WEN1_20
+  WENY0_20 WENY1_20 sram464x144RDM2X2
XL_RDM_21 D0_21 D1_21 DUM_SEL_D_R_104 DUM_SEL_D_R_108 DUM_SEL_TD_R_106
+  DUM_SEL_TD_R_110 Q0_21 Q1_21 SAO0_21 SAO1_21 TD0_21 TD1_21 TWEN0_21
+  TWEN1_21 VDDCE_21 VDDPE_21 VNWP_21 VPW_21 VSS_21 VSS_21 WEN0_21 WEN1_21
+  WENY0_21 WENY1_21 sram464x144RDM2X2
XL_RDM_22 D0_22 D1_22 DUM_SEL_D_R_108 DUM_SEL_D_R_112 DUM_SEL_TD_R_110
+  DUM_SEL_TD_R_114 Q0_22 Q1_22 SAO0_22 SAO1_22 TD0_22 TD1_22 TWEN0_22
+  TWEN1_22 VDDCE_22 VDDPE_22 VNWP_22 VPW_22 VSS_22 VSS_22 WEN0_22 WEN1_22
+  WENY0_22 WENY1_22 sram464x144RDM2X2
XL_RDM_23 D0_23 D1_23 DUM_SEL_D_R_112 DUM_SEL_D_R_116 DUM_SEL_TD_R_114
+  DUM_SEL_TD_R_118 Q0_23 Q1_23 SAO0_23 SAO1_23 TD0_23 TD1_23 TWEN0_23
+  TWEN1_23 VDDCE_23 VDDPE_23 VNWP_23 VPW_23 VSS_23 VSS_23 WEN0_23 WEN1_23
+  WENY0_23 WENY1_23 sram464x144RDM2X2
XL_RDM_24 D0_24 D1_24 DUM_SEL_D_R_116 DUM_SEL_D_R_120 DUM_SEL_TD_R_118
+  DUM_SEL_TD_R_122 Q0_24 Q1_24 SAO0_24 SAO1_24 TD0_24 TD1_24 TWEN0_24
+  TWEN1_24 VDDCE_24 VDDPE_24 VNWP_24 VPW_24 VSS_24 VSS_24 WEN0_24 WEN1_24
+  WENY0_24 WENY1_24 sram464x144RDM2X2
XL_RDM_25 D0_25 D1_25 DUM_SEL_D_R_120 DUM_SEL_D_R_124 DUM_SEL_TD_R_122
+  DUM_SEL_TD_R_126 Q0_25 Q1_25 SAO0_25 SAO1_25 TD0_25 TD1_25 TWEN0_25
+  TWEN1_25 VDDCE_25 VDDPE_25 VNWP_25 VPW_25 VSS_25 VSS_25 WEN0_25 WEN1_25
+  WENY0_25 WENY1_25 sram464x144RDM2X2
XL_RDM_26 D0_26 D1_26 DUM_SEL_D_R_124 DUM_SEL_D_R_128 DUM_SEL_TD_R_126
+  DUM_SEL_TD_R_130 Q0_26 Q1_26 SAO0_26 SAO1_26 TD0_26 TD1_26 TWEN0_26
+  TWEN1_26 VDDCE_26 VDDPE_26 VNWP_26 VPW_26 VSS_26 VSS_26 WEN0_26 WEN1_26
+  WENY0_26 WENY1_26 sram464x144RDM2X2
XL_RDM_27 D0_27 D1_27 DUM_SEL_D_R_128 DUM_SEL_D_R_132 DUM_SEL_TD_R_130
+  DUM_SEL_TD_R_134 Q0_27 Q1_27 SAO0_27 SAO1_27 TD0_27 TD1_27 TWEN0_27
+  TWEN1_27 VDDCE_27 VDDPE_27 VNWP_27 VPW_27 VSS_27 VSS_27 WEN0_27 WEN1_27
+  WENY0_27 WENY1_27 sram464x144RDM2X2
XL_RDM_28 D0_28 D1_28 DUM_SEL_D_R_132 DUM_SEL_D_R_136 DUM_SEL_TD_R_134
+  DUM_SEL_TD_R_138 Q0_28 Q1_28 SAO0_28 SAO1_28 TD0_28 TD1_28 TWEN0_28
+  TWEN1_28 VDDCE_28 VDDPE_28 VNWP_28 VPW_28 VSS_28 VSS_28 WEN0_28 WEN1_28
+  WENY0_28 WENY1_28 sram464x144RDM2X2
XL_RDM_29 D0_29 D1_29 DUM_SEL_D_R_136 DUM_SEL_D_L_16 DUM_SEL_TD_R_138
+  DUM_SEL_TD_L_18 Q0_29 Q1_29 SAO0_29 SAO1_29 TD0_29 TD1_29 TWEN0_29 TWEN1_29
+  VDDCE_29 VDDPE_29 VNWP_29 VPW_29 VSS_29 VSS_29 WEN0_29 WEN1_29 WENY0_29
+  WENY1_29 sram464x144RDM2X2
XL_RDM_3 D0_3 D1_3 DUM_SEL_D_R_76 DUM_SEL_D_R_80 DUM_SEL_TD_R_78
+  DUM_SEL_TD_R_82 Q0_3 Q1_3 SAO0_3 SAO1_3 TD0_3 TD1_3 TWEN0_3 TWEN1_3 VDDCE_3
+  VDDPE_3 VNWP_3 VPW_3 VSS_3 VSS_3 WEN0_3 WEN1_3 WENY0_3 WENY1_3
+  sram464x144RDM2X2
XL_RDM_30 D0_30 D1_30 DUM_SEL_D_L_16 DUM_SEL_D_R_12 DUM_SEL_TD_L_18
+  DUM_SEL_TD_R_14 Q0_30 Q1_30 SAO0_30 SAO1_30 TD0_30 TD1_30 TWEN0_30 TWEN1_30
+  VDDCE_30 VDDPE_30 VNWP_30 VPW_30 VSS_30 VSS_30 WEN0_30 WEN1_30 WENY0_30
+  WENY1_30 sram464x144RDM2X2
XL_RDM_31 D0_31 D1_31 DUM_SEL_D_R_12 DUM_SEL_D_R_24 DUM_SEL_TD_R_14
+  DUM_SEL_TD_R_26 Q0_31 Q1_31 SAO0_31 SAO1_31 TD0_31 TD1_31 TWEN0_31 TWEN1_31
+  VDDCE_31 VDDPE_31 VNWP_31 VPW_31 VSS_31 VSS_31 WEN0_31 WEN1_31 WENY0_31
+  WENY1_31 sram464x144RDM2X2
XL_RDM_32 D0_32 D1_32 DUM_SEL_D_R_24 DUM_SEL_D_R_32 DUM_SEL_TD_R_26
+  DUM_SEL_TD_R_34 Q0_32 Q1_32 SAO0_32 SAO1_32 TD0_32 TD1_32 TWEN0_32 TWEN1_32
+  VDDCE_32 VDDPE_32 VNWP_32 VPW_32 VSS_32 VSS_32 WEN0_32 WEN1_32 WENY0_32
+  WENY1_32 sram464x144RDM2X2
XL_RDM_33 D0_33 D1_33 DUM_SEL_D_R_32 DUM_SEL_D_R_40 DUM_SEL_TD_R_34
+  DUM_SEL_TD_R_42 Q0_33 Q1_33 SAO0_33 SAO1_33 TD0_33 TD1_33 TWEN0_33 TWEN1_33
+  VDDCE_33 VDDPE_33 VNWP_33 VPW_33 VSS_33 VSS_33 WEN0_33 WEN1_33 WENY0_33
+  WENY1_33 sram464x144RDM2X2
XL_RDM_34 D0_34 D1_34 DUM_SEL_D_R_40 DUM_SEL_D_R_48 DUM_SEL_TD_R_42
+  DUM_SEL_TD_R_50 Q0_34 Q1_34 SAO0_34 SAO1_34 TD0_34 TD1_34 TWEN0_34 TWEN1_34
+  VDDCE_34 VDDPE_34 VNWP_34 VPW_34 VSS_34 VSS_34 WEN0_34 WEN1_34 WENY0_34
+  WENY1_34 sram464x144RDM2X2
XL_RDM_4 D0_4 D1_4 DUM_SEL_D_R_80 DUM_SEL_D_R_84 DUM_SEL_TD_R_82
+  DUM_SEL_TD_R_86 Q0_4 Q1_4 SAO0_4 SAO1_4 TD0_4 TD1_4 TWEN0_4 TWEN1_4 VDDCE_4
+  VDDPE_4 VNWP_4 VPW_4 VSS_4 VSS_4 WEN0_4 WEN1_4 WENY0_4 WENY1_4
+  sram464x144RDM2X2
XL_RDM_5 D0_5 D1_5 DUM_SEL_D_R_84 DUM_SEL_D_R_88 DUM_SEL_TD_R_86
+  DUM_SEL_TD_R_90 Q0_5 Q1_5 SAO0_5 SAO1_5 TD0_5 TD1_5 TWEN0_5 TWEN1_5 VDDCE_5
+  VDDPE_5 VNWP_5 VPW_5 VSS_5 VSS_5 WEN0_5 WEN1_5 WENY0_5 WENY1_5
+  sram464x144RDM2X2
XL_RDM_6 D0_6 D1_6 DUM_SEL_D_R_88 DUM_SEL_D_R_92 DUM_SEL_TD_R_90
+  DUM_SEL_TD_R_94 Q0_6 Q1_6 SAO0_6 SAO1_6 TD0_6 TD1_6 TWEN0_6 TWEN1_6 VDDCE_6
+  VDDPE_6 VNWP_6 VPW_6 VSS_6 VSS_6 WEN0_6 WEN1_6 WENY0_6 WENY1_6
+  sram464x144RDM2X2
XL_RDM_7 D0_7 D1_7 DUM_SEL_D_R_92 DUM_SEL_D_R_96 DUM_SEL_TD_R_94
+  DUM_SEL_TD_R_98 Q0_7 Q1_7 SAO0_7 SAO1_7 TD0_7 TD1_7 TWEN0_7 TWEN1_7 VDDCE_7
+  VDDPE_7 VNWP_7 VPW_7 VSS_7 VSS_7 WEN0_7 WEN1_7 WENY0_7 WENY1_7
+  sram464x144RDM2X2
XL_RDM_8 D0_8 D1_8 DUM_SEL_D_R_96 DUM_SEL_D_R_100 DUM_SEL_TD_R_98
+  DUM_SEL_TD_R_102 Q0_8 Q1_8 SAO0_8 SAO1_8 TD0_8 TD1_8 TWEN0_8 TWEN1_8
+  VDDCE_8 VDDPE_8 VNWP_8 VPW_8 VSS_8 VSS_8 WEN0_8 WEN1_8 WENY0_8 WENY1_8
+  sram464x144RDM2X2
XL_RDM_9 D0_9 D1_9 DUM_SEL_D_R_100 DUM_SEL_D_L_4 DUM_SEL_TD_R_102
+  DUM_SEL_TD_L_6 Q0_9 Q1_9 SAO0_9 SAO1_9 TD0_9 TD1_9 TWEN0_9 TWEN1_9 VDDCE_9
+  VDDPE_9 VNWP_9 VPW_9 VSS_9 VSS_9 WEN0_9 WEN1_9 WENY0_9 WENY1_9
+  sram464x144RDM2X2
XL_RDM_L D0_0 D1_0 DUM_SEL_D_L DUM_SEL_D_R_68 DUM_SEL_TD_L DUM_SEL_TD_R_70
+  Q0_0 Q1_0 SAO0_0 SAO1_0 TD0_0 TD1_0 TWEN0_0 TWEN1_0 VDDCE_0 VDDPE_0 VNWP_0
+  VPW_0 VSS_0 VSS_0 WEN0_0 WEN1_0 WENY0_0 WENY1_0 sram464x144RDM2X2
XL_RDM_R D0_35 D1_35 DUM_SEL_D_R_48 DUM_SEL_D_R DUM_SEL_TD_R_50 DUM_SEL_TD_R
+  Q0_35 Q1_35 SAO0_35 SAO1_35 TD0_35 TD1_35 TWEN0_35 TWEN1_35 VDDCE_35
+  VDDPE_35 VNWP_35 VPW_35 VSS_35 VSS_35 WEN0_35 WEN1_35 WENY0_35 WENY1_35
+  sram464x144RDM2X2
.ENDS sram464x144IO_RDM_L
****
.SUBCKT sram464x144CCHD4_TOPBOT BL[0] BL[1] BL[2] BL[3] NBL[0] NBL[1] NBL[2]
+  NBL[3] VDDC VDDCE VDDPE VNWC VPW VSSE
** sram464x144CCHD4_TOPBOT: 32 flat devices **
X_MXN16 VSSE NET150 NET93 VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MXN17 NBL[2] VPW NET97 VPW dslnfetwl_ckt W=0.11U L=0.059U
X_MXN18 NET88 VPW NBL[3] VPW dslnfetwl_ckt W=0.11U L=0.059U
X_MXN19 VPW VPW NET45 VPW dslnfetwl_ckt W=0.11U L=0.059U
X_MXN20 NET80 NET154 VSSE VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MXN21 VPW NET146 VPW VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MXN22 VPW NET114 NET61 VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MXN23 VPW NET158 VPW VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MXN24 NET84 VPW VPW VPW dslnfetwl_ckt W=0.11U L=0.059U
X_MXN25 VPW NET142 NET57 VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MXN26 VPW NET138 NET49 VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MXN27 NET64 VPW VPW VPW dslnfetwl_ckt W=0.11U L=0.059U
X_MXN28 VPW NET130 VPW VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MXN29 VPW NET126 NET37 VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MXN30 VPW NET134 VPW VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MXN31 NET32 NET118 VSSE VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MXN32 VPW VPW NET41 VPW dslnfetwl_ckt W=0.11U L=0.059U
X_MXN33 NET104 VPW NBL[1] VPW dslnfetwl_ckt W=0.11U L=0.059U
X_MXN34 NBL[0] VPW NET101 VPW dslnfetwl_ckt W=0.11U L=0.059U
X_MXN35 VSSE NET122 NET73 VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MXP12 NET149 NET150 VDDC VNWC dslpfetpu_ckt W=0.06U L=0.055U
X_MXP13 VDDC NET154 NET151 VNWC dslpfetpu_ckt W=0.06U L=0.055U
X_MXP14 VNWC NET158 VNWC VNWC dslpfetpu_ckt W=0.06U L=0.055U
X_MXP15 NET113 NET114 VNWC VNWC dslpfetpu_ckt W=0.06U L=0.055U
X_MXP16 NET141 NET142 VNWC VNWC dslpfetpu_ckt W=0.06U L=0.055U
X_MXP17 VNWC NET146 VNWC VNWC dslpfetpu_ckt W=0.06U L=0.055U
X_MXP20 VNWC NET134 VNWC VNWC dslpfetpu_ckt W=0.06U L=0.055U
X_MXP21 NET137 NET138 VNWC VNWC dslpfetpu_ckt W=0.06U L=0.055U
X_MXP22 NET125 NET126 VNWC VNWC dslpfetpu_ckt W=0.06U L=0.055U
X_MXP23 VNWC NET130 VNWC VNWC dslpfetpu_ckt W=0.06U L=0.055U
X_MXP24 VDDC NET118 NET115 VNWC dslpfetpu_ckt W=0.06U L=0.055U
X_MXP25 NET121 NET122 VDDC VNWC dslpfetpu_ckt W=0.06U L=0.055U
.ENDS sram464x144CCHD4_TOPBOT
****
.SUBCKT sram464x144IOTOPCAP_L BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5
+  BL[0]_6 BL[0]_7 BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13
+  BL[0]_14 BL[0]_15 BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21
+  BL[0]_22 BL[0]_23 BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29
+  BL[0]_30 BL[0]_31 BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1
+  BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10
+  BL[1]_11 BL[1]_12 BL[1]_13 BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18
+  BL[1]_19 BL[1]_20 BL[1]_21 BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26
+  BL[1]_27 BL[1]_28 BL[1]_29 BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34
+  BL[1]_35 BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7
+  BL[2]_8 BL[2]_9 BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15
+  BL[2]_16 BL[2]_17 BL[2]_18 BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23
+  BL[2]_24 BL[2]_25 BL[2]_26 BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31
+  BL[2]_32 BL[2]_33 BL[2]_34 BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4
+  BL[3]_5 BL[3]_6 BL[3]_7 BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13
+  BL[3]_14 BL[3]_15 BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21
+  BL[3]_22 BL[3]_23 BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29
+  BL[3]_30 BL[3]_31 BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1
+  NBL[0]_2 NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9
+  NBL[0]_10 NBL[0]_11 NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16
+  NBL[0]_17 NBL[0]_18 NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23
+  NBL[0]_24 NBL[0]_25 NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30
+  NBL[0]_31 NBL[0]_32 NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1
+  NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9
+  NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16
+  NBL[1]_17 NBL[1]_18 NBL[1]_19 NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23
+  NBL[1]_24 NBL[1]_25 NBL[1]_26 NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30
+  NBL[1]_31 NBL[1]_32 NBL[1]_33 NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1
+  NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9
+  NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13 NBL[2]_14 NBL[2]_15 NBL[2]_16
+  NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20 NBL[2]_21 NBL[2]_22 NBL[2]_23
+  NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27 NBL[2]_28 NBL[2]_29 NBL[2]_30
+  NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34 NBL[2]_35 NBL[3]_0 NBL[3]_1
+  NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 NBL[3]_8 NBL[3]_9
+  NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13 NBL[3]_14 NBL[3]_15 NBL[3]_16
+  NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20 NBL[3]_21 NBL[3]_22 NBL[3]_23
+  NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27 NBL[3]_28 NBL[3]_29 NBL[3]_30
+  NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34 NBL[3]_35 VDDC VDDPE_0 VDDPE_1
+  VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8 VDDPE_9 VDDPE_10
+  VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16 VDDPE_17 VDDPE_18
+  VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24 VDDPE_25 VDDPE_26
+  VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32 VDDPE_33 VDDPE_34
+  VDDPE_35 VPW
** sram464x144IOTOPCAP_L: 1152 flat devices **
XIOTOPCAP_L0 BL[0]_0 BL[1]_0 BL[2]_0 BL[3]_0 NBL[0]_0 NBL[1]_0 NBL[2]_0
+  NBL[3]_0 VDDC VDDC VDDPE_0 VDDC VPW VPW sram464x144CCHD4_TOPBOT
XIOTOPCAP_L1 BL[0]_1 BL[1]_1 BL[2]_1 BL[3]_1 NBL[0]_1 NBL[1]_1 NBL[2]_1
+  NBL[3]_1 VDDC VDDC VDDPE_1 VDDC VPW VPW sram464x144CCHD4_TOPBOT
XIOTOPCAP_L10 BL[0]_10 BL[1]_10 BL[2]_10 BL[3]_10 NBL[0]_10 NBL[1]_10
+  NBL[2]_10 NBL[3]_10 VDDC VDDC VDDPE_10 VDDC VPW VPW sram464x144CCHD4_TOPBOT
XIOTOPCAP_L11 BL[0]_11 BL[1]_11 BL[2]_11 BL[3]_11 NBL[0]_11 NBL[1]_11
+  NBL[2]_11 NBL[3]_11 VDDC VDDC VDDPE_11 VDDC VPW VPW sram464x144CCHD4_TOPBOT
XIOTOPCAP_L12 BL[0]_12 BL[1]_12 BL[2]_12 BL[3]_12 NBL[0]_12 NBL[1]_12
+  NBL[2]_12 NBL[3]_12 VDDC VDDC VDDPE_12 VDDC VPW VPW sram464x144CCHD4_TOPBOT
XIOTOPCAP_L13 BL[0]_13 BL[1]_13 BL[2]_13 BL[3]_13 NBL[0]_13 NBL[1]_13
+  NBL[2]_13 NBL[3]_13 VDDC VDDC VDDPE_13 VDDC VPW VPW sram464x144CCHD4_TOPBOT
XIOTOPCAP_L14 BL[0]_14 BL[1]_14 BL[2]_14 BL[3]_14 NBL[0]_14 NBL[1]_14
+  NBL[2]_14 NBL[3]_14 VDDC VDDC VDDPE_14 VDDC VPW VPW sram464x144CCHD4_TOPBOT
XIOTOPCAP_L15 BL[0]_15 BL[1]_15 BL[2]_15 BL[3]_15 NBL[0]_15 NBL[1]_15
+  NBL[2]_15 NBL[3]_15 VDDC VDDC VDDPE_15 VDDC VPW VPW sram464x144CCHD4_TOPBOT
XIOTOPCAP_L16 BL[0]_16 BL[1]_16 BL[2]_16 BL[3]_16 NBL[0]_16 NBL[1]_16
+  NBL[2]_16 NBL[3]_16 VDDC VDDC VDDPE_16 VDDC VPW VPW sram464x144CCHD4_TOPBOT
XIOTOPCAP_L17 BL[0]_17 BL[1]_17 BL[2]_17 BL[3]_17 NBL[0]_17 NBL[1]_17
+  NBL[2]_17 NBL[3]_17 VDDC VDDC VDDPE_17 VDDC VPW VPW sram464x144CCHD4_TOPBOT
XIOTOPCAP_L18 BL[0]_18 BL[1]_18 BL[2]_18 BL[3]_18 NBL[0]_18 NBL[1]_18
+  NBL[2]_18 NBL[3]_18 VDDC VDDC VDDPE_18 VDDC VPW VPW sram464x144CCHD4_TOPBOT
XIOTOPCAP_L19 BL[0]_19 BL[1]_19 BL[2]_19 BL[3]_19 NBL[0]_19 NBL[1]_19
+  NBL[2]_19 NBL[3]_19 VDDC VDDC VDDPE_19 VDDC VPW VPW sram464x144CCHD4_TOPBOT
XIOTOPCAP_L2 BL[0]_2 BL[1]_2 BL[2]_2 BL[3]_2 NBL[0]_2 NBL[1]_2 NBL[2]_2
+  NBL[3]_2 VDDC VDDC VDDPE_2 VDDC VPW VPW sram464x144CCHD4_TOPBOT
XIOTOPCAP_L20 BL[0]_20 BL[1]_20 BL[2]_20 BL[3]_20 NBL[0]_20 NBL[1]_20
+  NBL[2]_20 NBL[3]_20 VDDC VDDC VDDPE_20 VDDC VPW VPW sram464x144CCHD4_TOPBOT
XIOTOPCAP_L21 BL[0]_21 BL[1]_21 BL[2]_21 BL[3]_21 NBL[0]_21 NBL[1]_21
+  NBL[2]_21 NBL[3]_21 VDDC VDDC VDDPE_21 VDDC VPW VPW sram464x144CCHD4_TOPBOT
XIOTOPCAP_L22 BL[0]_22 BL[1]_22 BL[2]_22 BL[3]_22 NBL[0]_22 NBL[1]_22
+  NBL[2]_22 NBL[3]_22 VDDC VDDC VDDPE_22 VDDC VPW VPW sram464x144CCHD4_TOPBOT
XIOTOPCAP_L23 BL[0]_23 BL[1]_23 BL[2]_23 BL[3]_23 NBL[0]_23 NBL[1]_23
+  NBL[2]_23 NBL[3]_23 VDDC VDDC VDDPE_23 VDDC VPW VPW sram464x144CCHD4_TOPBOT
XIOTOPCAP_L24 BL[0]_24 BL[1]_24 BL[2]_24 BL[3]_24 NBL[0]_24 NBL[1]_24
+  NBL[2]_24 NBL[3]_24 VDDC VDDC VDDPE_24 VDDC VPW VPW sram464x144CCHD4_TOPBOT
XIOTOPCAP_L25 BL[0]_25 BL[1]_25 BL[2]_25 BL[3]_25 NBL[0]_25 NBL[1]_25
+  NBL[2]_25 NBL[3]_25 VDDC VDDC VDDPE_25 VDDC VPW VPW sram464x144CCHD4_TOPBOT
XIOTOPCAP_L26 BL[0]_26 BL[1]_26 BL[2]_26 BL[3]_26 NBL[0]_26 NBL[1]_26
+  NBL[2]_26 NBL[3]_26 VDDC VDDC VDDPE_26 VDDC VPW VPW sram464x144CCHD4_TOPBOT
XIOTOPCAP_L27 BL[0]_27 BL[1]_27 BL[2]_27 BL[3]_27 NBL[0]_27 NBL[1]_27
+  NBL[2]_27 NBL[3]_27 VDDC VDDC VDDPE_27 VDDC VPW VPW sram464x144CCHD4_TOPBOT
XIOTOPCAP_L28 BL[0]_28 BL[1]_28 BL[2]_28 BL[3]_28 NBL[0]_28 NBL[1]_28
+  NBL[2]_28 NBL[3]_28 VDDC VDDC VDDPE_28 VDDC VPW VPW sram464x144CCHD4_TOPBOT
XIOTOPCAP_L29 BL[0]_29 BL[1]_29 BL[2]_29 BL[3]_29 NBL[0]_29 NBL[1]_29
+  NBL[2]_29 NBL[3]_29 VDDC VDDC VDDPE_29 VDDC VPW VPW sram464x144CCHD4_TOPBOT
XIOTOPCAP_L3 BL[0]_3 BL[1]_3 BL[2]_3 BL[3]_3 NBL[0]_3 NBL[1]_3 NBL[2]_3
+  NBL[3]_3 VDDC VDDC VDDPE_3 VDDC VPW VPW sram464x144CCHD4_TOPBOT
XIOTOPCAP_L30 BL[0]_30 BL[1]_30 BL[2]_30 BL[3]_30 NBL[0]_30 NBL[1]_30
+  NBL[2]_30 NBL[3]_30 VDDC VDDC VDDPE_30 VDDC VPW VPW sram464x144CCHD4_TOPBOT
XIOTOPCAP_L31 BL[0]_31 BL[1]_31 BL[2]_31 BL[3]_31 NBL[0]_31 NBL[1]_31
+  NBL[2]_31 NBL[3]_31 VDDC VDDC VDDPE_31 VDDC VPW VPW sram464x144CCHD4_TOPBOT
XIOTOPCAP_L32 BL[0]_32 BL[1]_32 BL[2]_32 BL[3]_32 NBL[0]_32 NBL[1]_32
+  NBL[2]_32 NBL[3]_32 VDDC VDDC VDDPE_32 VDDC VPW VPW sram464x144CCHD4_TOPBOT
XIOTOPCAP_L33 BL[0]_33 BL[1]_33 BL[2]_33 BL[3]_33 NBL[0]_33 NBL[1]_33
+  NBL[2]_33 NBL[3]_33 VDDC VDDC VDDPE_33 VDDC VPW VPW sram464x144CCHD4_TOPBOT
XIOTOPCAP_L34 BL[0]_34 BL[1]_34 BL[2]_34 BL[3]_34 NBL[0]_34 NBL[1]_34
+  NBL[2]_34 NBL[3]_34 VDDC VDDC VDDPE_34 VDDC VPW VPW sram464x144CCHD4_TOPBOT
XIOTOPCAP_L35 BL[0]_35 BL[1]_35 BL[2]_35 BL[3]_35 NBL[0]_35 NBL[1]_35
+  NBL[2]_35 NBL[3]_35 VDDC VDDC VDDPE_35 VDDC VPW VPW sram464x144CCHD4_TOPBOT
XIOTOPCAP_L4 BL[0]_4 BL[1]_4 BL[2]_4 BL[3]_4 NBL[0]_4 NBL[1]_4 NBL[2]_4
+  NBL[3]_4 VDDC VDDC VDDPE_4 VDDC VPW VPW sram464x144CCHD4_TOPBOT
XIOTOPCAP_L5 BL[0]_5 BL[1]_5 BL[2]_5 BL[3]_5 NBL[0]_5 NBL[1]_5 NBL[2]_5
+  NBL[3]_5 VDDC VDDC VDDPE_5 VDDC VPW VPW sram464x144CCHD4_TOPBOT
XIOTOPCAP_L6 BL[0]_6 BL[1]_6 BL[2]_6 BL[3]_6 NBL[0]_6 NBL[1]_6 NBL[2]_6
+  NBL[3]_6 VDDC VDDC VDDPE_6 VDDC VPW VPW sram464x144CCHD4_TOPBOT
XIOTOPCAP_L7 BL[0]_7 BL[1]_7 BL[2]_7 BL[3]_7 NBL[0]_7 NBL[1]_7 NBL[2]_7
+  NBL[3]_7 VDDC VDDC VDDPE_7 VDDC VPW VPW sram464x144CCHD4_TOPBOT
XIOTOPCAP_L8 BL[0]_8 BL[1]_8 BL[2]_8 BL[3]_8 NBL[0]_8 NBL[1]_8 NBL[2]_8
+  NBL[3]_8 VDDC VDDC VDDPE_8 VDDC VPW VPW sram464x144CCHD4_TOPBOT
XIOTOPCAP_L9 BL[0]_9 BL[1]_9 BL[2]_9 BL[3]_9 NBL[0]_9 NBL[1]_9 NBL[2]_9
+  NBL[3]_9 VDDC VDDC VDDPE_9 VDDC VPW VPW sram464x144CCHD4_TOPBOT
.ENDS sram464x144IOTOPCAP_L
****
.SUBCKT sram464x144IO_ROW_L BLPRECH BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4
+  BL[0]_5 BL[0]_6 BL[0]_7 BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13
+  BL[0]_14 BL[0]_15 BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21
+  BL[0]_22 BL[0]_23 BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29
+  BL[0]_30 BL[0]_31 BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1
+  BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10
+  BL[1]_11 BL[1]_12 BL[1]_13 BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18
+  BL[1]_19 BL[1]_20 BL[1]_21 BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26
+  BL[1]_27 BL[1]_28 BL[1]_29 BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34
+  BL[1]_35 BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7
+  BL[2]_8 BL[2]_9 BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15
+  BL[2]_16 BL[2]_17 BL[2]_18 BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23
+  BL[2]_24 BL[2]_25 BL[2]_26 BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31
+  BL[2]_32 BL[2]_33 BL[2]_34 BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4
+  BL[3]_5 BL[3]_6 BL[3]_7 BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13
+  BL[3]_14 BL[3]_15 BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21
+  BL[3]_22 BL[3]_23 BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29
+  BL[3]_30 BL[3]_31 BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 D0_0 D0_1 D0_2 D0_3
+  D0_4 D0_5 D0_6 D0_7 D0_8 D0_9 D0_10 D0_11 D0_12 D0_13 D0_14 D0_15 D0_16
+  D0_17 D0_18 D0_19 D0_20 D0_21 D0_22 D0_23 D0_24 D0_25 D0_26 D0_27 D0_28
+  D0_29 D0_30 D0_31 D0_32 D0_33 D0_34 D0_35 D1_0 D1_1 D1_2 D1_3 D1_4 D1_5
+  D1_6 D1_7 D1_8 D1_9 D1_10 D1_11 D1_12 D1_13 D1_14 D1_15 D1_16 D1_17 D1_18
+  D1_19 D1_20 D1_21 D1_22 D1_23 D1_24 D1_25 D1_26 D1_27 D1_28 D1_29 D1_30
+  D1_31 D1_32 D1_33 D1_34 D1_35 DUM_SEL_D_R DUM_SEL_TD_R DWL LOG0_0 LOG0_1
+  NACT_CC NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6
+  NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11 NBL[0]_12 NBL[0]_13
+  NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18 NBL[0]_19 NBL[0]_20
+  NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25 NBL[0]_26 NBL[0]_27
+  NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32 NBL[0]_33 NBL[0]_34
+  NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6
+  NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13
+  NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19 NBL[1]_20
+  NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26 NBL[1]_27
+  NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33 NBL[1]_34
+  NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6
+  NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 NSAE NWCLK NYR0 NYR1 Q0_0 Q0_1 Q0_2 Q0_3 Q0_4 Q0_5 Q0_6 Q0_7 Q0_8
+  Q0_9 Q0_10 Q0_11 Q0_12 Q0_13 Q0_14 Q0_15 Q0_16 Q0_17 Q0_18 Q0_19 Q0_20
+  Q0_21 Q0_22 Q0_23 Q0_24 Q0_25 Q0_26 Q0_27 Q0_28 Q0_29 Q0_30 Q0_31 Q0_32
+  Q0_33 Q0_34 Q0_35 Q1_0 Q1_1 Q1_2 Q1_3 Q1_4 Q1_5 Q1_6 Q1_7 Q1_8 Q1_9 Q1_10
+  Q1_11 Q1_12 Q1_13 Q1_14 Q1_15 Q1_16 Q1_17 Q1_18 Q1_19 Q1_20 Q1_21 Q1_22
+  Q1_23 Q1_24 Q1_25 Q1_26 Q1_27 Q1_28 Q1_29 Q1_30 Q1_31 Q1_32 Q1_33 Q1_34
+  Q1_35 SAPRECH TD0_0 TD0_1 TD0_2 TD0_3 TD0_4 TD0_5 TD0_6 TD0_7 TD0_8 TD0_9
+  TD0_10 TD0_11 TD0_12 TD0_13 TD0_14 TD0_15 TD0_16 TD0_17 TD0_18 TD0_19
+  TD0_20 TD0_21 TD0_22 TD0_23 TD0_24 TD0_25 TD0_26 TD0_27 TD0_28 TD0_29
+  TD0_30 TD0_31 TD0_32 TD0_33 TD0_34 TD0_35 TD1_0 TD1_1 TD1_2 TD1_3 TD1_4
+  TD1_5 TD1_6 TD1_7 TD1_8 TD1_9 TD1_10 TD1_11 TD1_12 TD1_13 TD1_14 TD1_15
+  TD1_16 TD1_17 TD1_18 TD1_19 TD1_20 TD1_21 TD1_22 TD1_23 TD1_24 TD1_25
+  TD1_26 TD1_27 TD1_28 TD1_29 TD1_30 TD1_31 TD1_32 TD1_33 TD1_34 TD1_35
+  TWEN0_0 TWEN0_1 TWEN0_2 TWEN0_3 TWEN0_4 TWEN0_5 TWEN0_6 TWEN0_7 TWEN0_8
+  TWEN0_9 TWEN0_10 TWEN0_11 TWEN0_12 TWEN0_13 TWEN0_14 TWEN0_15 TWEN0_16
+  TWEN0_17 TWEN0_18 TWEN0_19 TWEN0_20 TWEN0_21 TWEN0_22 TWEN0_23 TWEN0_24
+  TWEN0_25 TWEN0_26 TWEN0_27 TWEN0_28 TWEN0_29 TWEN0_30 TWEN0_31 TWEN0_32
+  TWEN0_33 TWEN0_34 TWEN0_35 TWEN1_0 TWEN1_1 TWEN1_2 TWEN1_3 TWEN1_4 TWEN1_5
+  TWEN1_6 TWEN1_7 TWEN1_8 TWEN1_9 TWEN1_10 TWEN1_11 TWEN1_12 TWEN1_13
+  TWEN1_14 TWEN1_15 TWEN1_16 TWEN1_17 TWEN1_18 TWEN1_19 TWEN1_20 TWEN1_21
+  TWEN1_22 TWEN1_23 TWEN1_24 TWEN1_25 TWEN1_26 TWEN1_27 TWEN1_28 TWEN1_29
+  TWEN1_30 TWEN1_31 TWEN1_32 TWEN1_33 TWEN1_34 TWEN1_35 VDDCE VDDPE VPW
+  WEN0_0 WEN0_1 WEN0_2 WEN0_3 WEN0_4 WEN0_5 WEN0_6 WEN0_7 WEN0_8 WEN0_9
+  WEN0_10 WEN0_11 WEN0_12 WEN0_13 WEN0_14 WEN0_15 WEN0_16 WEN0_17 WEN0_18
+  WEN0_19 WEN0_20 WEN0_21 WEN0_22 WEN0_23 WEN0_24 WEN0_25 WEN0_26 WEN0_27
+  WEN0_28 WEN0_29 WEN0_30 WEN0_31 WEN0_32 WEN0_33 WEN0_34 WEN0_35 WEN1_0
+  WEN1_1 WEN1_2 WEN1_3 WEN1_4 WEN1_5 WEN1_6 WEN1_7 WEN1_8 WEN1_9 WEN1_10
+  WEN1_11 WEN1_12 WEN1_13 WEN1_14 WEN1_15 WEN1_16 WEN1_17 WEN1_18 WEN1_19
+  WEN1_20 WEN1_21 WEN1_22 WEN1_23 WEN1_24 WEN1_25 WEN1_26 WEN1_27 WEN1_28
+  WEN1_29 WEN1_30 WEN1_31 WEN1_32 WEN1_33 WEN1_34 WEN1_35 WENY0_0 WENY0_1
+  WENY0_2 WENY0_3 WENY0_4 WENY0_5 WENY0_6 WENY0_7 WENY0_8 WENY0_9 WENY0_10
+  WENY0_11 WENY0_12 WENY0_13 WENY0_14 WENY0_15 WENY0_16 WENY0_17 WENY0_18
+  WENY0_19 WENY0_20 WENY0_21 WENY0_22 WENY0_23 WENY0_24 WENY0_25 WENY0_26
+  WENY0_27 WENY0_28 WENY0_29 WENY0_30 WENY0_31 WENY0_32 WENY0_33 WENY0_34
+  WENY0_35 WENY1_0 WENY1_1 WENY1_2 WENY1_3 WENY1_4 WENY1_5 WENY1_6 WENY1_7
+  WENY1_8 WENY1_9 WENY1_10 WENY1_11 WENY1_12 WENY1_13 WENY1_14 WENY1_15
+  WENY1_16 WENY1_17 WENY1_18 WENY1_19 WENY1_20 WENY1_21 WENY1_22 WENY1_23
+  WENY1_24 WENY1_25 WENY1_26 WENY1_27 WENY1_28 WENY1_29 WENY1_30 WENY1_31
+  WENY1_32 WENY1_33 WENY1_34 WENY1_35 YW0 YW1
** sram464x144IO_ROW_L: 6089 flat devices **
XIO_CDM_ROW_L BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 BLPRECH D0_0 D0_1 D0_2 D0_3 D0_4 D0_5
+  D0_6 D0_7 D0_8 D0_9 D0_10 D0_11 D0_12 D0_13 D0_14 D0_15 D0_16 D0_17 D0_18
+  D0_19 D0_20 D0_21 D0_22 D0_23 D0_24 D0_25 D0_26 D0_27 D0_28 D0_29 D0_30
+  D0_31 D0_32 D0_33 D0_34 D0_35 D1_0 D1_1 D1_2 D1_3 D1_4 D1_5 D1_6 D1_7 D1_8
+  D1_9 D1_10 D1_11 D1_12 D1_13 D1_14 D1_15 D1_16 D1_17 D1_18 D1_19 D1_20
+  D1_21 D1_22 D1_23 D1_24 D1_25 D1_26 D1_27 D1_28 D1_29 D1_30 D1_31 D1_32
+  D1_33 D1_34 D1_35 TD1_0 TD1_1 TD1_2 TD1_3 TD1_4 TD1_5 TD1_6 TD1_7 TD1_8
+  TD1_9 TD1_10 TD1_11 TD1_12 TD1_13 TD1_14 TD1_15 TD1_16 TD1_17 TD1_18 TD1_19
+  TD1_20 TD1_21 TD1_22 TD1_23 TD1_24 TD1_25 TD1_26 TD1_27 TD1_28 TD1_29
+  TD1_30 TD1_31 TD1_32 TD1_33 TD1_34 TD1_35 WEN1_0 WEN1_1 WEN1_2 WEN1_3
+  WEN1_4 WEN1_5 WEN1_6 WEN1_7 WEN1_8 WEN1_9 WEN1_10 WEN1_11 WEN1_12 WEN1_13
+  WEN1_14 WEN1_15 WEN1_16 WEN1_17 WEN1_18 WEN1_19 WEN1_20 WEN1_21 WEN1_22
+  WEN1_23 WEN1_24 WEN1_25 WEN1_26 WEN1_27 WEN1_28 WEN1_29 WEN1_30 WEN1_31
+  WEN1_32 WEN1_33 WEN1_34 WEN1_35 TWEN1_0 TWEN1_1 TWEN1_2 TWEN1_3 TWEN1_4
+  TWEN1_5 TWEN1_6 TWEN1_7 TWEN1_8 TWEN1_9 TWEN1_10 TWEN1_11 TWEN1_12 TWEN1_13
+  TWEN1_14 TWEN1_15 TWEN1_16 TWEN1_17 TWEN1_18 TWEN1_19 TWEN1_20 TWEN1_21
+  TWEN1_22 TWEN1_23 TWEN1_24 TWEN1_25 TWEN1_26 TWEN1_27 TWEN1_28 TWEN1_29
+  TWEN1_30 TWEN1_31 TWEN1_32 TWEN1_33 TWEN1_34 TWEN1_35 WENY1_0 WENY1_1
+  WENY1_2 WENY1_3 WENY1_4 WENY1_5 WENY1_6 WENY1_7 WENY1_8 WENY1_9 WENY1_10
+  WENY1_11 WENY1_12 WENY1_13 WENY1_14 WENY1_15 WENY1_16 WENY1_17 WENY1_18
+  WENY1_19 WENY1_20 WENY1_21 WENY1_22 WENY1_23 WENY1_24 WENY1_25 WENY1_26
+  WENY1_27 WENY1_28 WENY1_29 WENY1_30 WENY1_31 WENY1_32 WENY1_33 WENY1_34
+  WENY1_35 WENY0_0 WENY0_1 WENY0_2 WENY0_3 WENY0_4 WENY0_5 WENY0_6 WENY0_7
+  WENY0_8 WENY0_9 WENY0_10 WENY0_11 WENY0_12 WENY0_13 WENY0_14 WENY0_15
+  WENY0_16 WENY0_17 WENY0_18 WENY0_19 WENY0_20 WENY0_21 WENY0_22 WENY0_23
+  WENY0_24 WENY0_25 WENY0_26 WENY0_27 WENY0_28 WENY0_29 WENY0_30 WENY0_31
+  WENY0_32 WENY0_33 WENY0_34 WENY0_35 TWEN0_0 TWEN0_1 TWEN0_2 TWEN0_3 TWEN0_4
+  TWEN0_5 TWEN0_6 TWEN0_7 TWEN0_8 TWEN0_9 TWEN0_10 TWEN0_11 TWEN0_12 TWEN0_13
+  TWEN0_14 TWEN0_15 TWEN0_16 TWEN0_17 TWEN0_18 TWEN0_19 TWEN0_20 TWEN0_21
+  TWEN0_22 TWEN0_23 TWEN0_24 TWEN0_25 TWEN0_26 TWEN0_27 TWEN0_28 TWEN0_29
+  TWEN0_30 TWEN0_31 TWEN0_32 TWEN0_33 TWEN0_34 TWEN0_35 WEN0_0 WEN0_1 WEN0_2
+  WEN0_3 WEN0_4 WEN0_5 WEN0_6 WEN0_7 WEN0_8 WEN0_9 WEN0_10 WEN0_11 WEN0_12
+  WEN0_13 WEN0_14 WEN0_15 WEN0_16 WEN0_17 WEN0_18 WEN0_19 WEN0_20 WEN0_21
+  WEN0_22 WEN0_23 WEN0_24 WEN0_25 WEN0_26 WEN0_27 WEN0_28 WEN0_29 WEN0_30
+  WEN0_31 WEN0_32 WEN0_33 WEN0_34 WEN0_35 TD0_0 TD0_1 TD0_2 TD0_3 TD0_4 TD0_5
+  TD0_6 TD0_7 TD0_8 TD0_9 TD0_10 TD0_11 TD0_12 TD0_13 TD0_14 TD0_15 TD0_16
+  TD0_17 TD0_18 TD0_19 TD0_20 TD0_21 TD0_22 TD0_23 TD0_24 TD0_25 TD0_26
+  TD0_27 TD0_28 TD0_29 TD0_30 TD0_31 TD0_32 TD0_33 TD0_34 TD0_35 DWL LOG0_1
+  NACT_CC NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6
+  NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11 NBL[0]_12 NBL[0]_13
+  NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18 NBL[0]_19 NBL[0]_20
+  NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25 NBL[0]_26 NBL[0]_27
+  NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32 NBL[0]_33 NBL[0]_34
+  NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6
+  NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13
+  NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19 NBL[1]_20
+  NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26 NBL[1]_27
+  NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33 NBL[1]_34
+  NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6
+  NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 NSAE NWCLK NYR0 NYR1 SAO0_0 SAO0_1 SAO0_2 SAO0_3 SAO0_4 SAO0_5
+  SAO0_6 SAO0_7 SAO0_8 SAO0_9 SAO0_10 SAO0_11 SAO0_12 SAO0_13 SAO0_14 SAO0_15
+  SAO0_16 SAO0_17 SAO0_18 SAO0_19 SAO0_20 SAO0_21 SAO0_22 SAO0_23 SAO0_24
+  SAO0_25 SAO0_26 SAO0_27 SAO0_28 SAO0_29 SAO0_30 SAO0_31 SAO0_32 SAO0_33
+  SAO0_34 SAO0_35 SAO1_0 SAO1_1 SAO1_2 SAO1_3 SAO1_4 SAO1_5 SAO1_6 SAO1_7
+  SAO1_8 SAO1_9 SAO1_10 SAO1_11 SAO1_12 SAO1_13 SAO1_14 SAO1_15 SAO1_16
+  SAO1_17 SAO1_18 SAO1_19 SAO1_20 SAO1_21 SAO1_22 SAO1_23 SAO1_24 SAO1_25
+  SAO1_26 SAO1_27 SAO1_28 SAO1_29 SAO1_30 SAO1_31 SAO1_32 SAO1_33 SAO1_34
+  SAO1_35 SAPRECH VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE
+  VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE
+  VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE
+  VDDCE VDDCE VDDCE VDDPE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE
+  VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE
+  VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE
+  VDDCE VDDCE VDDCE VDDCE VPW YW0 YW1 sram464x144IOCDM_L
XIO_EDGE_L BLPRECH DUM_SEL_D DUM_SEL_TD DWL LOG0_0 LOG0_1 NACT_CC NSAE NWCLK
+  NYR0 NYR1 SAPRECH VDDCE VDDCE VDDPE VDDCE VPW VPW YW0 YW1 sram464x144IOEDGE
XIO_RDM_ROW_L D0_0 D0_1 D0_2 D0_3 D0_4 D0_5 D0_6 D0_7 D0_8 D0_9 D0_10 D0_11
+  D0_12 D0_13 D0_14 D0_15 D0_16 D0_17 D0_18 D0_19 D0_20 D0_21 D0_22 D0_23
+  D0_24 D0_25 D0_26 D0_27 D0_28 D0_29 D0_30 D0_31 D0_32 D0_33 D0_34 D0_35
+  D1_0 D1_1 D1_2 D1_3 D1_4 D1_5 D1_6 D1_7 D1_8 D1_9 D1_10 D1_11 D1_12 D1_13
+  D1_14 D1_15 D1_16 D1_17 D1_18 D1_19 D1_20 D1_21 D1_22 D1_23 D1_24 D1_25
+  D1_26 D1_27 D1_28 D1_29 D1_30 D1_31 D1_32 D1_33 D1_34 D1_35 DUM_SEL_D
+  DUM_SEL_D_R DUM_SEL_TD DUM_SEL_TD_R Q0_0 Q0_1 Q0_2 Q0_3 Q0_4 Q0_5 Q0_6 Q0_7
+  Q0_8 Q0_9 Q0_10 Q0_11 Q0_12 Q0_13 Q0_14 Q0_15 Q0_16 Q0_17 Q0_18 Q0_19 Q0_20
+  Q0_21 Q0_22 Q0_23 Q0_24 Q0_25 Q0_26 Q0_27 Q0_28 Q0_29 Q0_30 Q0_31 Q0_32
+  Q0_33 Q0_34 Q0_35 Q1_0 Q1_1 Q1_2 Q1_3 Q1_4 Q1_5 Q1_6 Q1_7 Q1_8 Q1_9 Q1_10
+  Q1_11 Q1_12 Q1_13 Q1_14 Q1_15 Q1_16 Q1_17 Q1_18 Q1_19 Q1_20 Q1_21 Q1_22
+  Q1_23 Q1_24 Q1_25 Q1_26 Q1_27 Q1_28 Q1_29 Q1_30 Q1_31 Q1_32 Q1_33 Q1_34
+  Q1_35 SAO0_0 SAO0_1 SAO0_2 SAO0_3 SAO0_4 SAO0_5 SAO0_6 SAO0_7 SAO0_8 SAO0_9
+  SAO0_10 SAO0_11 SAO0_12 SAO0_13 SAO0_14 SAO0_15 SAO0_16 SAO0_17 SAO0_18
+  SAO0_19 SAO0_20 SAO0_21 SAO0_22 SAO0_23 SAO0_24 SAO0_25 SAO0_26 SAO0_27
+  SAO0_28 SAO0_29 SAO0_30 SAO0_31 SAO0_32 SAO0_33 SAO0_34 SAO0_35 SAO1_0
+  SAO1_1 SAO1_2 SAO1_3 SAO1_4 SAO1_5 SAO1_6 SAO1_7 SAO1_8 SAO1_9 SAO1_10
+  SAO1_11 SAO1_12 SAO1_13 SAO1_14 SAO1_15 SAO1_16 SAO1_17 SAO1_18 SAO1_19
+  SAO1_20 SAO1_21 SAO1_22 SAO1_23 SAO1_24 SAO1_25 SAO1_26 SAO1_27 SAO1_28
+  SAO1_29 SAO1_30 SAO1_31 SAO1_32 SAO1_33 SAO1_34 SAO1_35 TD0_0 TD0_1 TD0_2
+  TD0_3 TD0_4 TD0_5 TD0_6 TD0_7 TD0_8 TD0_9 TD0_10 TD0_11 TD0_12 TD0_13
+  TD0_14 TD0_15 TD0_16 TD0_17 TD0_18 TD0_19 TD0_20 TD0_21 TD0_22 TD0_23
+  TD0_24 TD0_25 TD0_26 TD0_27 TD0_28 TD0_29 TD0_30 TD0_31 TD0_32 TD0_33
+  TD0_34 TD0_35 TD1_0 TD1_1 TD1_2 TD1_3 TD1_4 TD1_5 TD1_6 TD1_7 TD1_8 TD1_9
+  TD1_10 TD1_11 TD1_12 TD1_13 TD1_14 TD1_15 TD1_16 TD1_17 TD1_18 TD1_19
+  TD1_20 TD1_21 TD1_22 TD1_23 TD1_24 TD1_25 TD1_26 TD1_27 TD1_28 TD1_29
+  TD1_30 TD1_31 TD1_32 TD1_33 TD1_34 TD1_35 TWEN0_0 TWEN0_1 TWEN0_2 TWEN0_3
+  TWEN0_4 TWEN0_5 TWEN0_6 TWEN0_7 TWEN0_8 TWEN0_9 TWEN0_10 TWEN0_11 TWEN0_12
+  TWEN0_13 TWEN0_14 TWEN0_15 TWEN0_16 TWEN0_17 TWEN0_18 TWEN0_19 TWEN0_20
+  TWEN0_21 TWEN0_22 TWEN0_23 TWEN0_24 TWEN0_25 TWEN0_26 TWEN0_27 TWEN0_28
+  TWEN0_29 TWEN0_30 TWEN0_31 TWEN0_32 TWEN0_33 TWEN0_34 TWEN0_35 TWEN1_0
+  TWEN1_1 TWEN1_2 TWEN1_3 TWEN1_4 TWEN1_5 TWEN1_6 TWEN1_7 TWEN1_8 TWEN1_9
+  TWEN1_10 TWEN1_11 TWEN1_12 TWEN1_13 TWEN1_14 TWEN1_15 TWEN1_16 TWEN1_17
+  TWEN1_18 TWEN1_19 TWEN1_20 TWEN1_21 TWEN1_22 TWEN1_23 TWEN1_24 TWEN1_25
+  TWEN1_26 TWEN1_27 TWEN1_28 TWEN1_29 TWEN1_30 TWEN1_31 TWEN1_32 TWEN1_33
+  TWEN1_34 TWEN1_35 VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE
+  VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE
+  VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE
+  VDDCE VDDCE VDDCE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE
+  VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE
+  VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE
+  VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE
+  VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE
+  VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE
+  VDDPE VDDPE VDDPE VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW WEN0_0 WEN0_1 WEN0_2 WEN0_3 WEN0_4 WEN0_5 WEN0_6 WEN0_7 WEN0_8 WEN0_9
+  WEN0_10 WEN0_11 WEN0_12 WEN0_13 WEN0_14 WEN0_15 WEN0_16 WEN0_17 WEN0_18
+  WEN0_19 WEN0_20 WEN0_21 WEN0_22 WEN0_23 WEN0_24 WEN0_25 WEN0_26 WEN0_27
+  WEN0_28 WEN0_29 WEN0_30 WEN0_31 WEN0_32 WEN0_33 WEN0_34 WEN0_35 WEN1_0
+  WEN1_1 WEN1_2 WEN1_3 WEN1_4 WEN1_5 WEN1_6 WEN1_7 WEN1_8 WEN1_9 WEN1_10
+  WEN1_11 WEN1_12 WEN1_13 WEN1_14 WEN1_15 WEN1_16 WEN1_17 WEN1_18 WEN1_19
+  WEN1_20 WEN1_21 WEN1_22 WEN1_23 WEN1_24 WEN1_25 WEN1_26 WEN1_27 WEN1_28
+  WEN1_29 WEN1_30 WEN1_31 WEN1_32 WEN1_33 WEN1_34 WEN1_35 WENY0_0 WENY0_1
+  WENY0_2 WENY0_3 WENY0_4 WENY0_5 WENY0_6 WENY0_7 WENY0_8 WENY0_9 WENY0_10
+  WENY0_11 WENY0_12 WENY0_13 WENY0_14 WENY0_15 WENY0_16 WENY0_17 WENY0_18
+  WENY0_19 WENY0_20 WENY0_21 WENY0_22 WENY0_23 WENY0_24 WENY0_25 WENY0_26
+  WENY0_27 WENY0_28 WENY0_29 WENY0_30 WENY0_31 WENY0_32 WENY0_33 WENY0_34
+  WENY0_35 WENY1_0 WENY1_1 WENY1_2 WENY1_3 WENY1_4 WENY1_5 WENY1_6 WENY1_7
+  WENY1_8 WENY1_9 WENY1_10 WENY1_11 WENY1_12 WENY1_13 WENY1_14 WENY1_15
+  WENY1_16 WENY1_17 WENY1_18 WENY1_19 WENY1_20 WENY1_21 WENY1_22 WENY1_23
+  WENY1_24 WENY1_25 WENY1_26 WENY1_27 WENY1_28 WENY1_29 WENY1_30 WENY1_31
+  WENY1_32 WENY1_33 WENY1_34 WENY1_35 sram464x144IO_RDM_L
XIO_TOPCAP_ROW_L BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6
+  BL[0]_7 BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14
+  BL[0]_15 BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22
+  BL[0]_23 BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30
+  BL[0]_31 BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2
+  BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11
+  BL[1]_12 BL[1]_13 BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19
+  BL[1]_20 BL[1]_21 BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27
+  BL[1]_28 BL[1]_29 BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35
+  BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8
+  BL[2]_9 BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16
+  BL[2]_17 BL[2]_18 BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24
+  BL[2]_25 BL[2]_26 BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32
+  BL[2]_33 BL[2]_34 BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5
+  BL[3]_6 BL[3]_7 BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13
+  BL[3]_14 BL[3]_15 BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21
+  BL[3]_22 BL[3]_23 BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29
+  BL[3]_30 BL[3]_31 BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1
+  NBL[0]_2 NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9
+  NBL[0]_10 NBL[0]_11 NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16
+  NBL[0]_17 NBL[0]_18 NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23
+  NBL[0]_24 NBL[0]_25 NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30
+  NBL[0]_31 NBL[0]_32 NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1
+  NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9
+  NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16
+  NBL[1]_17 NBL[1]_18 NBL[1]_19 NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23
+  NBL[1]_24 NBL[1]_25 NBL[1]_26 NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30
+  NBL[1]_31 NBL[1]_32 NBL[1]_33 NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1
+  NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9
+  NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13 NBL[2]_14 NBL[2]_15 NBL[2]_16
+  NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20 NBL[2]_21 NBL[2]_22 NBL[2]_23
+  NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27 NBL[2]_28 NBL[2]_29 NBL[2]_30
+  NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34 NBL[2]_35 NBL[3]_0 NBL[3]_1
+  NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 NBL[3]_8 NBL[3]_9
+  NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13 NBL[3]_14 NBL[3]_15 NBL[3]_16
+  NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20 NBL[3]_21 NBL[3]_22 NBL[3]_23
+  NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27 NBL[3]_28 NBL[3]_29 NBL[3]_30
+  NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34 NBL[3]_35 VDDCE VDDPE VDDPE VDDPE
+  VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE
+  VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE
+  VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VPW
+  sram464x144IOTOPCAP_L
.ENDS sram464x144IO_ROW_L
****
.SUBCKT sram464x144CKM2 ACTP BLPRECH_L BLPRECH_R CA0 CA1 CA2 CEN CLK DBL
+  DUM_SEL_D_L DUM_SEL_D_R DUM_SEL_TD_L DUM_SEL_TD_R DWL EMAW[0] EMAW[1]
+  EMA[0] EMA[1] EMA[2] GTP GWEN IRA_P2[5] LA0 LA1 LA2 LA_P2[0] LA_P2[1]
+  LA_P2[2] LOG0 LOG0_DWL LOG1 NACTC NACT_CC NGWE NRETNVT NSAE NWCLK NYR0 NYR1
+  RA0 RA1 RA2 RA3 RA4 RA5 RA_P2[0] RA_P2[1] RA_P2[2] RA_P2[3] RA_P2[4]
+  RA_P2[5] RDT RET RET1N SAE_DUMMY SAPRECH VDDCE VDDC_L VDDC_LEFT VDDC_R
+  VDDC_RIGHT VDDP VDDPE VDDP_CLKGEN VNWC VNWP VPW VSS VSSE YW0 YW1
** sram464x144CKM2: 491 flat devices **
X_MI0.MXNA1 NET0362 RET1N I0.N1 VPW N11LL_CKT W=0.15U L=0.04U
X_MI0.MXNA2 I0.N1 WEMA00_N VSSE VPW N11LL_CKT W=0.15U L=0.04U
X_MI0.MXPA1 NET0362 RET1N VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_MI0.MXPA2 NET0362 WEMA00_N VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_MI1.MXNA1 BCLK_GTPSA NET0319 I1.N1 VPW N11LL_CKT W=0.6U L=0.04U
X_MI1.MXNA2 I1.N1 WRITE_NGTP VSS VPW N11LL_CKT W=0.6U L=0.04U
X_MI1.MXPA1 BCLK_GTPSA NET0319 VDDPE VNWP P11LL_CKT W=0.4U L=0.04U
X_MI1.MXPA2 BCLK_GTPSA WRITE_NGTP VDDPE VNWP P11LL_CKT W=0.4U L=0.04U
X_MI100.MXN0 VSSE I100.NET19 I100.NET18 VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MI100.MXN2 VPW I100.NET15 I100.NET14 VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MI100.MXN3 VPW I100.NET23 VPW VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MI115.MXNA1 NRDT_RD GWEN_P2 I115.N2 VPW N11LL_CKT W=0.425U L=0.04U
X_MI115.MXNA2 I115.N2 RET1N I115.N1 VPW N11LL_CKT W=0.425U L=0.04U
X_MI115.MXNA3 I115.N1 RDT_P2 VSS VPW N11LL_CKT W=0.425U L=0.04U
X_MI115.MXPA1 NRDT_RD GWEN_P2 VDDPE VNWP P11LL_CKT W=0.28U L=0.04U
X_MI115.MXPA2 NRDT_RD RET1N VDDPE VNWP P11LL_CKT W=0.28U L=0.04U
X_MI115.MXPA3 NRDT_RD RDT_P2 VDDPE VNWP P11LL_CKT W=0.28U L=0.04U
X_MI120.MXNA1 RDT_RD NRDT_RD VSSE VPW N11LL_CKT W=0.6U L=0.04U
X_MI120.MXPA1 RDT_RD NRDT_RD VDDPE VNWP P11LL_CKT W=0.79U L=0.04U
X_MI122.MXNA1 NSAPRECH ISAPRECH VSS VPW N11LL_CKT W=1.415U L=0.04U
X_MI122.MXPA1 NSAPRECH ISAPRECH VDDPE VNWP P11LL_CKT W=2.835U L=0.04U
X_MI123.MXNA1 NET0319 GTP VSS VPW N11LL_CKT W=0.14U L=0.04U
X_MI123.MXNA2 NET0319 GTPSA_SPLIT VSS VPW N11LL_CKT W=0.14U L=0.04U
X_MI123.MXPA1 NET0319 GTP I123.P1 VNWP P11LL_CKT W=0.6U L=0.04U
X_MI123.MXPA2 I123.P1 GTPSA_SPLIT VDDPE VNWP P11LL_CKT W=0.6U L=0.04U
X_MI125.MXNA1 I125.N1 CA_P2[0] VSS VPW N11LL_CKT W=0.285U L=0.04U
X_MI125.MXNOE NET0359 CA_P2[0] I125.N1 VPW N11LL_CKT W=0.285U L=0.04U
X_MI125.MXPA1 I125.P1 CA_P2[0] VDDPE VNWP P11LL_CKT W=0.565U L=0.04U
X_MI125.MXPOEN NET0359 CA_P2[0] I125.P1 VNWP P11LL_CKT W=0.565U L=0.04U
X_MI126.MXNA1 CADDR0 NET0359 VSS VPW N11LL_CKT W=0.285U L=0.04U
X_MI126.MXPA1 CADDR0 NET0359 VDDPE VNWP P11LL_CKT W=0.565U L=0.04U
X_MI127.MXNA1 NCADDR0 CADDR0 VSS VPW N11LL_CKT W=0.285U L=0.04U
X_MI127.MXPA1 NCADDR0 CADDR0 VDDPE VNWP P11LL_CKT W=0.565U L=0.04U
X_MI130.MXNA1 DFTRAM_NRET NET0437 VSSE VPW N11LL_CKT W=0.355U L=0.04U
X_MI130.MXPA1 DFTRAM_NRET NET0437 VDDCE VNWC P11LL_CKT W=0.71U L=0.04U
X_MI131.MXNA1 RET1N_WEMA00N NET0362 VSSE VPW N11LL_CKT W=0.15U L=0.04U
X_MI131.MXPA1 RET1N_WEMA00N NET0362 VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_MI144.MXNA1 NET0437 RET1N I144.N1 VPW N11LL_CKT W=0.285U L=0.04U
X_MI144.MXNA2 I144.N1 LOG1 VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MI144.MXPA1 NET0437 RET1N VDDCE VNWC P11LL_CKT W=0.285U L=0.04U
X_MI144.MXPA2 NET0437 LOG1 VDDCE VNWC P11LL_CKT W=0.285U L=0.04U
X_MI146.MXNA1 NCLK_GTPSA BCLK_GTPSA VSS VPW N11LL_CKT W=0.15U L=0.04U
X_MI146.MXPA1 NCLK_GTPSA BCLK_GTPSA VDDPE VNWP P11LL_CKT W=0.3U L=0.04U
X_MI148.MXNA1 ISAPRECH GTP VSS VPW N11LL_CKT W=0.425U L=0.04U
X_MI148.MXNA2 ISAPRECH GTPSA_SPLIT VSS VPW N11LL_CKT W=0.425U L=0.04U
X_MI148.MXPA1 ISAPRECH GTP I148.P1 VNWP P11LL_CKT W=0.85U L=0.04U
X_MI148.MXPA2 I148.P1 GTPSA_SPLIT VDDPE VNWP P11LL_CKT W=0.85U L=0.04U
X_MI151.MXNA1 NET0406 INSAE VSS VPW N11LL_CKT W=0.435U L=0.04U
X_MI151.MXPA1 NET0406 INSAE VDDPE VNWP P11LL_CKT W=0.285U L=0.04U
X_MI152.MXNA1 INSAE_DLY NET0406 VSS VPW N11LL_CKT W=0.145U L=0.04U
X_MI152.MXPA1 INSAE_DLY NET0406 VDDPE VNWP P11LL_CKT W=0.885U L=0.04U
X_MI156.MXN0 I156.NET44 I156.NET32 VSS VPW N11LL_CKT W=0.285U L=0.04U
X_MI156.MXN1 I156.NET40 DWL VSS VPW N11LL_CKT W=0.285U L=0.04U
X_MI156.MXN2 I156.NET36 I156.NET40 VSS VPW N11LL_CKT W=0.285U L=0.04U
X_MI156.MXN3 VSS I156.NET44 VSS VPW N11LL_CKT W=0.285U L=0.04U
X_MI156.MXN4 I156.NET32 I156.NET40 I156.NET36 VPW N11LL_CKT W=0.285U L=0.04U
X_MI156.MXN8 DWL_DLY I156.NET44 VSS VPW N11LL_CKT W=0.285U L=0.04U
X_MI156.MXP0 DWL_DLY I156.NET44 VDDPE VNWP P11LL_CKT W=0.28U L=0.04U
X_MI156.MXP1 I156.NET23 I156.NET32 VDDPE VNWP P11LL_CKT W=0.28U L=0.04U
X_MI156.MXP2 I156.NET44 I156.NET32 I156.NET23 VNWP P11LL_CKT W=0.28U L=0.04U
X_MI156.MXP4 I156.NET40 DWL VDDPE VNWP P11LL_CKT W=0.56U L=0.04U
X_MI156.MXP5 I156.NET32 I156.NET40 VDDPE VNWP P11LL_CKT W=0.28U L=0.04U
X_MI163.MXNA1 WEMA00 EMAW[0] VSSE VPW N11LL_CKT W=0.15U L=0.04U
X_MI163.MXNA2 WEMA00 EMAW[1] VSSE VPW N11LL_CKT W=0.15U L=0.04U
X_MI163.MXPA1 WEMA00 EMAW[0] I163.P1 VNWP P11LL_CKT W=0.17U L=0.04U
X_MI163.MXPA2 I163.P1 EMAW[1] VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_MI164.MXNA1 WEMA00_N WEMA00 VSSE VPW N11LL_CKT W=0.15U L=0.04U
X_MI164.MXPA1 WEMA00_N WEMA00 VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_MI32.MXNA1 NCLK GTP VSS VPW N11LL_CKT W=0.84U L=0.04U
X_MI32.MXPA1 NCLK GTP VDDPE VNWP P11LL_CKT W=1.71U L=0.04U
X_MI4.MXNA1 NICLK GTP VSS VPW N11LL_CKT W=0.42U L=0.04U
X_MI4.MXPA1 NICLK GTP VDDPE VNWP P11LL_CKT W=0.64U L=0.04U
X_MI5.MXNA1 BCLK NICLK VSS VPW N11LL_CKT W=0.84U L=0.04U
X_MI5.MXPA1 BCLK NICLK VDDPE VNWP P11LL_CKT W=1.71U L=0.04U
X_MI51.MXNA1 NGTP GTP VSS VPW N11LL_CKT W=0.855U L=0.04U
X_MI51.MXPA1 NGTP GTP VDDPE VNWP P11LL_CKT W=0.68U L=0.04U
X_MI52.MXNA1 RET DFTRAM_NRET VSSE VPW N11LL_CKT W=3.55U L=0.04U
X_MI52.MXPA1 RET DFTRAM_NRET VDDCE VNWC P11LL_CKT W=7.1U L=0.04U
X_MI81.MXNA1 INSAE GTPSA_SPLIT I81.N1 VPW N11LL_CKT W=0.565U L=0.04U
X_MI81.MXNA2 I81.N1 GWEN_P2 VSS VPW N11LL_CKT W=0.565U L=0.04U
X_MI81.MXPA1 INSAE GTPSA_SPLIT VDDPE VNWP P11LL_CKT W=0.685U L=0.04U
X_MI81.MXPA2 INSAE GWEN_P2 VDDPE VNWP P11LL_CKT W=0.685U L=0.04U
X_MI91.MXN0 VSSE I91.NET19 I91.NET18 VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MI91.MXN2 VPW I91.NET15 I91.NET14 VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MI91.MXN3 VPW I91.NET23 VPW VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MIV_ALat.MXNA1 GWEN_P2 GWE_P2 VSS VPW N11LL_CKT W=0.59U L=0.04U
X_MIV_ALat.MXPA1 GWEN_P2 GWE_P2 VDDPE VNWP P11LL_CKT W=0.8U L=0.04U
X_MIV_nALat.MXNA1 GWE_P2 GWEN_LAT_Q VSS VPW N11LL_CKT W=0.75U L=0.04U
X_MIV_nALat.MXPA1 GWE_P2 GWEN_LAT_Q VDDPE VNWP P11LL_CKT W=1.14U L=0.04U
X_MXN0 LOG0 LOG0 LOG0 VPW N11LL_CKT W=0.155U L=0.04U
X_MXN1 LOG0 LOG0 LOG0 VPW N11LL_CKT W=0.155U L=0.04U
X_MXN2 LOG0 LOG0 LOG0 VPW N11LL_CKT W=0.62U L=0.085U
X_MXN3 LOG0 LOG0 LOG0 VPW N11LL_CKT W=0.62U L=0.085U
X_MXN4 NSAE SAE VSS VPW N11LL_CKT W=4.25U L=0.04U
X_MXN6 SAE INSAE NET0240 VPW N11LL_CKT W=1.42U L=0.04U
X_MXN7 SAPRECH NSAPRECH VSS VPW N11LL_CKT W=4.26U L=0.04U
X_MXN9 NET0240 INSAE_DLY VSS VPW N11LL_CKT W=1.42U L=0.04U
X_MXP0 NSAE SAE VDDPE VNWP P11LL_CKT W=8.525U L=0.04U
X_MXP1 SAE INSAE VDDPE VNWP P11LL_CKT W=2.13U L=0.04U
X_MXP2 SAE INSAE_DLY VDDPE VNWP P11LL_CKT W=0.425U L=0.04U
X_MXP7 SAPRECH NSAPRECH VDDPE VNWP P11LL_CKT W=8.525U L=0.04U
X_M_addr_lat_0.I47.MXNA1 _ADDR_LAT_0.ND CA0 VSS VPW N11LL_CKT W=0.34U L=0.04U
X_M_addr_lat_0.I47.MXPA1 _ADDR_LAT_0.ND CA0 VDDPE VNWP P11LL_CKT W=0.68U
+  L=0.04U
X_M_addr_lat_0.I48.MXNOE NCA_P2[0] NCLK _ADDR_LAT_0.ND VPW N11LL_CKT W=0.34U
+  L=0.04U
X_M_addr_lat_0.I48.MXPOEN NCA_P2[0] BCLK _ADDR_LAT_0.ND VNWP P11LL_CKT W=0.34U
+  L=0.04U
X_M_addr_lat_0.I50.MXNA1 CA_P2[0] NCA_P2[0] VSS VPW N11LL_CKT W=0.4U L=0.04U
X_M_addr_lat_0.I50.MXPA1 CA_P2[0] NCA_P2[0] VDDPE VNWP P11LL_CKT W=0.57U
+  L=0.04U
X_M_addr_lat_0.I55.MXNA1 _ADDR_LAT_0.I55.N1 CA_P2[0] VSS VPW N11LL_CKT W=0.15U
+  L=0.04U
X_M_addr_lat_0.I55.MXNOE NCA_P2[0] BCLK _ADDR_LAT_0.I55.N1 VPW N11LL_CKT
+  W=0.15U L=0.04U
X_M_addr_lat_0.I55.MXPA1 _ADDR_LAT_0.I55.P1 CA_P2[0] VDDPE VNWP P11LL_CKT
+  W=0.15U L=0.04U
X_M_addr_lat_0.I55.MXPOEN NCA_P2[0] NCLK _ADDR_LAT_0.I55.P1 VNWP P11LL_CKT
+  W=0.15U L=0.04U
X_M_addr_lat_1.I47.MXNA1 _ADDR_LAT_1.ND LA0 VSS VPW N11LL_CKT W=0.34U L=0.04U
X_M_addr_lat_1.I47.MXPA1 _ADDR_LAT_1.ND LA0 VDDPE VNWP P11LL_CKT W=0.68U
+  L=0.04U
X_M_addr_lat_1.I48.MXNOE NLA_PA[0] NCLK _ADDR_LAT_1.ND VPW N11LL_CKT W=0.34U
+  L=0.04U
X_M_addr_lat_1.I48.MXPOEN NLA_PA[0] BCLK _ADDR_LAT_1.ND VNWP P11LL_CKT W=0.34U
+  L=0.04U
X_M_addr_lat_1.I50.MXNA1 LA_P2[0] NLA_PA[0] VSS VPW N11LL_CKT W=0.4U L=0.04U
X_M_addr_lat_1.I50.MXPA1 LA_P2[0] NLA_PA[0] VDDPE VNWP P11LL_CKT W=0.57U
+  L=0.04U
X_M_addr_lat_1.I55.MXNA1 _ADDR_LAT_1.I55.N1 LA_P2[0] VSS VPW N11LL_CKT W=0.15U
+  L=0.04U
X_M_addr_lat_1.I55.MXNOE NLA_PA[0] BCLK _ADDR_LAT_1.I55.N1 VPW N11LL_CKT
+  W=0.15U L=0.04U
X_M_addr_lat_1.I55.MXPA1 _ADDR_LAT_1.I55.P1 LA_P2[0] VDDPE VNWP P11LL_CKT
+  W=0.15U L=0.04U
X_M_addr_lat_1.I55.MXPOEN NLA_PA[0] NCLK _ADDR_LAT_1.I55.P1 VNWP P11LL_CKT
+  W=0.15U L=0.04U
X_M_addr_lat_2.I47.MXNA1 _ADDR_LAT_2.ND RA0 VSS VPW N11LL_CKT W=0.34U L=0.04U
X_M_addr_lat_2.I47.MXPA1 _ADDR_LAT_2.ND RA0 VDDPE VNWP P11LL_CKT W=0.68U
+  L=0.04U
X_M_addr_lat_2.I48.MXNOE NRA_P2[0] NCLK _ADDR_LAT_2.ND VPW N11LL_CKT W=0.34U
+  L=0.04U
X_M_addr_lat_2.I48.MXPOEN NRA_P2[0] BCLK _ADDR_LAT_2.ND VNWP P11LL_CKT W=0.34U
+  L=0.04U
X_M_addr_lat_2.I50.MXNA1 RA_P2[0] NRA_P2[0] VSS VPW N11LL_CKT W=0.4U L=0.04U
X_M_addr_lat_2.I50.MXPA1 RA_P2[0] NRA_P2[0] VDDPE VNWP P11LL_CKT W=0.57U
+  L=0.04U
X_M_addr_lat_2.I55.MXNA1 _ADDR_LAT_2.I55.N1 RA_P2[0] VSS VPW N11LL_CKT W=0.15U
+  L=0.04U
X_M_addr_lat_2.I55.MXNOE NRA_P2[0] BCLK _ADDR_LAT_2.I55.N1 VPW N11LL_CKT
+  W=0.15U L=0.04U
X_M_addr_lat_2.I55.MXPA1 _ADDR_LAT_2.I55.P1 RA_P2[0] VDDPE VNWP P11LL_CKT
+  W=0.15U L=0.04U
X_M_addr_lat_2.I55.MXPOEN NRA_P2[0] NCLK _ADDR_LAT_2.I55.P1 VNWP P11LL_CKT
+  W=0.15U L=0.04U
X_M_addr_lat_3.I47.MXNA1 _ADDR_LAT_3.ND RA1 VSS VPW N11LL_CKT W=0.34U L=0.04U
X_M_addr_lat_3.I47.MXPA1 _ADDR_LAT_3.ND RA1 VDDPE VNWP P11LL_CKT W=0.68U
+  L=0.04U
X_M_addr_lat_3.I48.MXNOE NRA_P2[1] NCLK _ADDR_LAT_3.ND VPW N11LL_CKT W=0.34U
+  L=0.04U
X_M_addr_lat_3.I48.MXPOEN NRA_P2[1] BCLK _ADDR_LAT_3.ND VNWP P11LL_CKT W=0.34U
+  L=0.04U
X_M_addr_lat_3.I50.MXNA1 RA_P2[1] NRA_P2[1] VSS VPW N11LL_CKT W=0.4U L=0.04U
X_M_addr_lat_3.I50.MXPA1 RA_P2[1] NRA_P2[1] VDDPE VNWP P11LL_CKT W=0.57U
+  L=0.04U
X_M_addr_lat_3.I55.MXNA1 _ADDR_LAT_3.I55.N1 RA_P2[1] VSS VPW N11LL_CKT W=0.15U
+  L=0.04U
X_M_addr_lat_3.I55.MXNOE NRA_P2[1] BCLK _ADDR_LAT_3.I55.N1 VPW N11LL_CKT
+  W=0.15U L=0.04U
X_M_addr_lat_3.I55.MXPA1 _ADDR_LAT_3.I55.P1 RA_P2[1] VDDPE VNWP P11LL_CKT
+  W=0.15U L=0.04U
X_M_addr_lat_3.I55.MXPOEN NRA_P2[1] NCLK _ADDR_LAT_3.I55.P1 VNWP P11LL_CKT
+  W=0.15U L=0.04U
X_M_addr_lat_4.I47.MXNA1 _ADDR_LAT_4.ND RA2 VSS VPW N11LL_CKT W=0.34U L=0.04U
X_M_addr_lat_4.I47.MXPA1 _ADDR_LAT_4.ND RA2 VDDPE VNWP P11LL_CKT W=0.68U
+  L=0.04U
X_M_addr_lat_4.I48.MXNOE NRA_P2[2] NCLK _ADDR_LAT_4.ND VPW N11LL_CKT W=0.34U
+  L=0.04U
X_M_addr_lat_4.I48.MXPOEN NRA_P2[2] BCLK _ADDR_LAT_4.ND VNWP P11LL_CKT W=0.34U
+  L=0.04U
X_M_addr_lat_4.I50.MXNA1 RA_P2[2] NRA_P2[2] VSS VPW N11LL_CKT W=0.4U L=0.04U
X_M_addr_lat_4.I50.MXPA1 RA_P2[2] NRA_P2[2] VDDPE VNWP P11LL_CKT W=0.57U
+  L=0.04U
X_M_addr_lat_4.I55.MXNA1 _ADDR_LAT_4.I55.N1 RA_P2[2] VSS VPW N11LL_CKT W=0.15U
+  L=0.04U
X_M_addr_lat_4.I55.MXNOE NRA_P2[2] BCLK _ADDR_LAT_4.I55.N1 VPW N11LL_CKT
+  W=0.15U L=0.04U
X_M_addr_lat_4.I55.MXPA1 _ADDR_LAT_4.I55.P1 RA_P2[2] VDDPE VNWP P11LL_CKT
+  W=0.15U L=0.04U
X_M_addr_lat_4.I55.MXPOEN NRA_P2[2] NCLK _ADDR_LAT_4.I55.P1 VNWP P11LL_CKT
+  W=0.15U L=0.04U
X_M_addr_lat_5.I47.MXNA1 _ADDR_LAT_5.ND RA3 VSS VPW N11LL_CKT W=0.34U L=0.04U
X_M_addr_lat_5.I47.MXPA1 _ADDR_LAT_5.ND RA3 VDDPE VNWP P11LL_CKT W=0.68U
+  L=0.04U
X_M_addr_lat_5.I48.MXNOE NRA_P2[3] NCLK _ADDR_LAT_5.ND VPW N11LL_CKT W=0.34U
+  L=0.04U
X_M_addr_lat_5.I48.MXPOEN NRA_P2[3] BCLK _ADDR_LAT_5.ND VNWP P11LL_CKT W=0.34U
+  L=0.04U
X_M_addr_lat_5.I50.MXNA1 RA_P2[3] NRA_P2[3] VSS VPW N11LL_CKT W=0.4U L=0.04U
X_M_addr_lat_5.I50.MXPA1 RA_P2[3] NRA_P2[3] VDDPE VNWP P11LL_CKT W=0.57U
+  L=0.04U
X_M_addr_lat_5.I55.MXNA1 _ADDR_LAT_5.I55.N1 RA_P2[3] VSS VPW N11LL_CKT W=0.15U
+  L=0.04U
X_M_addr_lat_5.I55.MXNOE NRA_P2[3] BCLK _ADDR_LAT_5.I55.N1 VPW N11LL_CKT
+  W=0.15U L=0.04U
X_M_addr_lat_5.I55.MXPA1 _ADDR_LAT_5.I55.P1 RA_P2[3] VDDPE VNWP P11LL_CKT
+  W=0.15U L=0.04U
X_M_addr_lat_5.I55.MXPOEN NRA_P2[3] NCLK _ADDR_LAT_5.I55.P1 VNWP P11LL_CKT
+  W=0.15U L=0.04U
X_M_addr_lat_6.I47.MXNA1 _ADDR_LAT_6.ND RA4 VSS VPW N11LL_CKT W=0.34U L=0.04U
X_M_addr_lat_6.I47.MXPA1 _ADDR_LAT_6.ND RA4 VDDPE VNWP P11LL_CKT W=0.68U
+  L=0.04U
X_M_addr_lat_6.I48.MXNOE NRA_P2[4] NCLK _ADDR_LAT_6.ND VPW N11LL_CKT W=0.34U
+  L=0.04U
X_M_addr_lat_6.I48.MXPOEN NRA_P2[4] BCLK _ADDR_LAT_6.ND VNWP P11LL_CKT W=0.34U
+  L=0.04U
X_M_addr_lat_6.I50.MXNA1 RA_P2[4] NRA_P2[4] VSS VPW N11LL_CKT W=0.4U L=0.04U
X_M_addr_lat_6.I50.MXPA1 RA_P2[4] NRA_P2[4] VDDPE VNWP P11LL_CKT W=0.57U
+  L=0.04U
X_M_addr_lat_6.I55.MXNA1 _ADDR_LAT_6.I55.N1 RA_P2[4] VSS VPW N11LL_CKT W=0.15U
+  L=0.04U
X_M_addr_lat_6.I55.MXNOE NRA_P2[4] BCLK _ADDR_LAT_6.I55.N1 VPW N11LL_CKT
+  W=0.15U L=0.04U
X_M_addr_lat_6.I55.MXPA1 _ADDR_LAT_6.I55.P1 RA_P2[4] VDDPE VNWP P11LL_CKT
+  W=0.15U L=0.04U
X_M_addr_lat_6.I55.MXPOEN NRA_P2[4] NCLK _ADDR_LAT_6.I55.P1 VNWP P11LL_CKT
+  W=0.15U L=0.04U
X_M_addr_lat_7.I47.MXNA1 _ADDR_LAT_7.ND RA5 VSS VPW N11LL_CKT W=0.34U L=0.04U
X_M_addr_lat_7.I47.MXPA1 _ADDR_LAT_7.ND RA5 VDDPE VNWP P11LL_CKT W=0.68U
+  L=0.04U
X_M_addr_lat_7.I48.MXNOE NRA_P2[5] NCLK _ADDR_LAT_7.ND VPW N11LL_CKT W=0.34U
+  L=0.04U
X_M_addr_lat_7.I48.MXPOEN NRA_P2[5] BCLK _ADDR_LAT_7.ND VNWP P11LL_CKT W=0.34U
+  L=0.04U
X_M_addr_lat_7.I50.MXNA1 IRA_P2[5] NRA_P2[5] VSS VPW N11LL_CKT W=0.4U L=0.04U
X_M_addr_lat_7.I50.MXPA1 IRA_P2[5] NRA_P2[5] VDDPE VNWP P11LL_CKT W=0.57U
+  L=0.04U
X_M_addr_lat_7.I55.MXNA1 _ADDR_LAT_7.I55.N1 IRA_P2[5] VSS VPW N11LL_CKT
+  W=0.15U L=0.04U
X_M_addr_lat_7.I55.MXNOE NRA_P2[5] BCLK _ADDR_LAT_7.I55.N1 VPW N11LL_CKT
+  W=0.15U L=0.04U
X_M_addr_lat_7.I55.MXPA1 _ADDR_LAT_7.I55.P1 IRA_P2[5] VDDPE VNWP P11LL_CKT
+  W=0.15U L=0.04U
X_M_addr_lat_7.I55.MXPOEN NRA_P2[5] NCLK _ADDR_LAT_7.I55.P1 VNWP P11LL_CKT
+  W=0.15U L=0.04U
X_M_addr_lat_8.I47.MXNA1 _ADDR_LAT_8.ND LA1 VSS VPW N11LL_CKT W=0.34U L=0.04U
X_M_addr_lat_8.I47.MXPA1 _ADDR_LAT_8.ND LA1 VDDPE VNWP P11LL_CKT W=0.68U
+  L=0.04U
X_M_addr_lat_8.I48.MXNOE NLA_P2[1] NCLK _ADDR_LAT_8.ND VPW N11LL_CKT W=0.34U
+  L=0.04U
X_M_addr_lat_8.I48.MXPOEN NLA_P2[1] BCLK _ADDR_LAT_8.ND VNWP P11LL_CKT W=0.34U
+  L=0.04U
X_M_addr_lat_8.I50.MXNA1 LA_P2[1] NLA_P2[1] VSS VPW N11LL_CKT W=0.4U L=0.04U
X_M_addr_lat_8.I50.MXPA1 LA_P2[1] NLA_P2[1] VDDPE VNWP P11LL_CKT W=0.57U
+  L=0.04U
X_M_addr_lat_8.I55.MXNA1 _ADDR_LAT_8.I55.N1 LA_P2[1] VSS VPW N11LL_CKT W=0.15U
+  L=0.04U
X_M_addr_lat_8.I55.MXNOE NLA_P2[1] BCLK _ADDR_LAT_8.I55.N1 VPW N11LL_CKT
+  W=0.15U L=0.04U
X_M_addr_lat_8.I55.MXPA1 _ADDR_LAT_8.I55.P1 LA_P2[1] VDDPE VNWP P11LL_CKT
+  W=0.15U L=0.04U
X_M_addr_lat_8.I55.MXPOEN NLA_P2[1] NCLK _ADDR_LAT_8.I55.P1 VNWP P11LL_CKT
+  W=0.15U L=0.04U
X_M_blprech.I51.MXNA1 _BLPRECH.DGTP_L _BLPRECH.IGTP VSSE VPW N11LL_CKT
+  W=0.285U L=0.04U
X_M_blprech.I51.MXNA2 _BLPRECH.DGTP_L _BLPRECH.DRET VSSE VPW N11LL_CKT
+  W=0.285U L=0.04U
X_M_blprech.I51.MXPA1 _BLPRECH.DGTP_L _BLPRECH.IGTP _BLPRECH.I51.P1 VNWP
+  P11LL_CKT W=0.35U L=0.04U
X_M_blprech.I51.MXPA2 _BLPRECH.I51.P1 _BLPRECH.DRET VDDPE VNWP P11LL_CKT
+  W=0.35U L=0.04U
X_M_blprech.I52.MXNA1 _BLPRECH.DGTP_R _BLPRECH.IGTP VSSE VPW N11LL_CKT
+  W=0.285U L=0.04U
X_M_blprech.I52.MXNA2 _BLPRECH.DGTP_R RET VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_M_blprech.I52.MXPA1 _BLPRECH.DGTP_R _BLPRECH.IGTP _BLPRECH.I52.P1 VNWP
+  P11LL_CKT W=0.35U L=0.04U
X_M_blprech.I52.MXPA2 _BLPRECH.I52.P1 RET VDDPE VNWP P11LL_CKT W=0.35U L=0.04U
X_M_blprech.I64.MXNA1 _BLPRECH.I64.N1 _BLPRECH.NET039 VSSE VPW N11LL_CKT
+  W=0.28U L=0.04U
X_M_blprech.I64.MXNOE _BLPRECH.NET047 _BLPRECH.NET039 _BLPRECH.I64.N1 VPW
+  N11LL_CKT W=0.28U L=0.04U
X_M_blprech.I64.MXPA1 _BLPRECH.I64.P1 _BLPRECH.NET039 VDDPE VNWP P11LL_CKT
+  W=0.425U L=0.04U
X_M_blprech.I64.MXPOEN _BLPRECH.NET047 _BLPRECH.NET039 _BLPRECH.I64.P1 VNWP
+  P11LL_CKT W=0.425U L=0.04U
X_M_blprech.I65.MXNA1 _BLPRECH.I65.N1 RET VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_M_blprech.I65.MXNOE _BLPRECH.NET039 RET _BLPRECH.I65.N1 VPW N11LL_CKT
+  W=0.285U L=0.04U
X_M_blprech.I65.MXPA1 _BLPRECH.I65.P1 RET VDDPE VNWP P11LL_CKT W=0.43U L=0.04U
X_M_blprech.I65.MXPOEN _BLPRECH.NET039 RET _BLPRECH.I65.P1 VNWP P11LL_CKT
+  W=0.43U L=0.04U
X_M_blprech.I68.MXNA1 _BLPRECH.DRET _BLPRECH.NET49 VSSE VPW N11LL_CKT W=0.17U
+  L=0.04U
X_M_blprech.I68.MXPA1 _BLPRECH.DRET _BLPRECH.NET49 VDDPE VNWP P11LL_CKT
+  W=0.345U L=0.04U
X_M_blprech.I69.MXNA1 _BLPRECH.NET49 RET VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_M_blprech.I69.MXNA2 _BLPRECH.NET49 _BLPRECH.NET047 VSSE VPW N11LL_CKT
+  W=0.285U L=0.04U
X_M_blprech.I69.MXPA1 _BLPRECH.NET49 RET _BLPRECH.I69.P1 VNWP P11LL_CKT
+  W=0.285U L=0.04U
X_M_blprech.I69.MXPA2 _BLPRECH.I69.P1 _BLPRECH.NET047 VDDPE VNWP P11LL_CKT
+  W=0.285U L=0.04U
X_M_blprech.MXN0 BLPRECH_R _BLPRECH.NBLPRECH_R VSSE VPW N11LL_CKT W=4.06U
+  L=0.04U
X_M_blprech.MXN1 BLPRECH_L _BLPRECH.NBLPRECH_L VSSE VPW N11LL_CKT W=4.06U
+  L=0.04U
X_M_blprech.MXN2 _BLPRECH.IGTP NGTP VSS VPW N11LL_CKT W=0.36U L=0.04U
X_M_blprech.MXN4 _BLPRECH.IGTP NGTP VSS VPW N11LL_CKT W=0.36U L=0.04U
X_M_blprech.MXP0 VDDPE RDT_RD VDDPE VNWP P11LL_CKT W=4.095U L=0.04U
X_M_blprech.MXP2 BLPRECH_R _BLPRECH.NBLPRECH_R VDDPE VNWP P11LL_CKT W=5.54U
+  L=0.04U
X_M_blprech.MXP3 BLPRECH_L _BLPRECH.NBLPRECH_L VDDPE VNWP P11LL_CKT W=5.54U
+  L=0.04U
X_M_blprech.MXP4 _BLPRECH.IGTP NGTP VDDPE VNWP P11LL_CKT W=0.285U L=0.04U
X_M_blprech._aoi_bl_f.MXN0 _BLPRECH.NBLPRECH_L NGTP _BLPRECH._AOI_BL_F.NET12
+  VPW N11LL_CKT W=0.51U L=0.04U
X_M_blprech._aoi_bl_f.MXN1 _BLPRECH._AOI_BL_F.NET12 _BLPRECH.DGTP_L VSS VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_blprech._aoi_bl_f.MXN2 _BLPRECH.NBLPRECH_L RDT_RD VSS VPW N11LL_CKT
+  W=0.34U L=0.04U
X_M_blprech._aoi_bl_f.MXP0 _BLPRECH.NBLPRECH_L NGTP VDDPE VNWP P11LL_CKT
+  W=1.365U L=0.04U
X_M_blprech._aoi_bl_f.MXP1 _BLPRECH.NBLPRECH_L _BLPRECH.DGTP_L VDDPE VNWP
+  P11LL_CKT W=1.365U L=0.04U
X_M_blprech._aoi_bl_r.MXN0 _BLPRECH.NBLPRECH_R NGTP _BLPRECH._AOI_BL_R.NET12
+  VPW N11LL_CKT W=0.51U L=0.04U
X_M_blprech._aoi_bl_r.MXN1 _BLPRECH._AOI_BL_R.NET12 _BLPRECH.DGTP_R VSS VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_blprech._aoi_bl_r.MXN2 _BLPRECH.NBLPRECH_R RDT_RD VSS VPW N11LL_CKT
+  W=0.34U L=0.04U
X_M_blprech._aoi_bl_r.MXP0 _BLPRECH.NBLPRECH_R NGTP VDDPE VNWP P11LL_CKT
+  W=1.365U L=0.04U
X_M_blprech._aoi_bl_r.MXP1 _BLPRECH.NBLPRECH_R _BLPRECH.DGTP_R VDDPE VNWP
+  P11LL_CKT W=1.365U L=0.04U
X_M_ckgen.I92.MXNA1 DWL _CKGEN.NGTP VSSE VPW N11LL_CKT W=2.13U L=0.04U
X_M_ckgen.I92.MXPA1 DWL _CKGEN.NGTP VDDP_CLKGEN VNWP P11LL_CKT W=4.26U L=0.04U
X_M_ckgen.Iema.I0.MXNA1 _CKGEN.IEMA.NGWE GWE_P2 _CKGEN.IEMA.I0.N1 VPW
+  N11LL_CKT W=0.28U L=0.04U
X_M_ckgen.Iema.I0.MXNA2 _CKGEN.IEMA.I0.N1 RET1N_WEMA00N VSSE VPW N11LL_CKT
+  W=0.28U L=0.04U
X_M_ckgen.Iema.I0.MXPA1 _CKGEN.IEMA.NGWE GWE_P2 VDDPE VNWP P11LL_CKT W=0.28U
+  L=0.04U
X_M_ckgen.Iema.I0.MXPA2 _CKGEN.IEMA.NGWE RET1N_WEMA00N VDDPE VNWP P11LL_CKT
+  W=0.28U L=0.04U
X_M_ckgen.Iema.I1.MXNA1 _CKGEN.IEMA.NRDLY GTPSA_SPLIT VSSE VPW N11LL_CKT
+  W=0.85U L=0.04U
X_M_ckgen.Iema.I1.MXPA1 _CKGEN.IEMA.NRDLY GTPSA_SPLIT VDDPE VNWP P11LL_CKT
+  W=1.28U L=0.04U
X_M_ckgen.Iema.I2.MXNA1 _CKGEN.IEMA.NWDLY _CKGEN.IEMA.WDLY VSSE VPW N11LL_CKT
+  W=0.85U L=0.04U
X_M_ckgen.Iema.I2.MXPA1 _CKGEN.IEMA.NWDLY _CKGEN.IEMA.WDLY VDDPE VNWP
+  P11LL_CKT W=1.28U L=0.04U
X_M_ckgen.Iema.I20.MXNOE _CKGEN.RESET _CKGEN.IEMA.NGWE _CKGEN.IEMA.NRDLY VPW
+  N11LL_CKT W=0.85U L=0.04U
X_M_ckgen.Iema.I20.MXPOEN _CKGEN.RESET _CKGEN.IEMA.IGWE _CKGEN.IEMA.NRDLY VNWP
+  P11LL_CKT W=0.85U L=0.04U
X_M_ckgen.Iema.I21.MXNOE _CKGEN.RESET _CKGEN.IEMA.IGWE _CKGEN.IEMA.NWDLY VPW
+  N11LL_CKT W=0.85U L=0.04U
X_M_ckgen.Iema.I21.MXPOEN _CKGEN.RESET _CKGEN.IEMA.NGWE _CKGEN.IEMA.NWDLY VNWP
+  P11LL_CKT W=0.85U L=0.04U
X_M_ckgen.Iema.I40.MXNA1 _CKGEN.IEMA.IGWE _CKGEN.IEMA.NGWE VSSE VPW N11LL_CKT
+  W=0.285U L=0.04U
X_M_ckgen.Iema.I40.MXPA1 _CKGEN.IEMA.IGWE _CKGEN.IEMA.NGWE VDDPE VNWP
+  P11LL_CKT W=0.425U L=0.04U
X_M_ckgen.Iema.I49.MXN3 _CKGEN.IEMA.I49.NET057 GTPSA_SPLIT
+  _CKGEN.IEMA.I49.NET049 VPW N11LL_CKT W=0.4U L=0.04U
X_M_ckgen.Iema.I49.MXN4 _CKGEN.IEMA.NET65 _CKGEN.IEMA.I49.NDIN VSSE VPW
+  N11LL_CKT W=0.4U L=0.04U
X_M_ckgen.Iema.I49.MXN8 _CKGEN.IEMA.I49.NDIN GTPSA_SPLIT
+  _CKGEN.IEMA.I49.NET057 VPW N11LL_CKT W=0.4U L=0.04U
X_M_ckgen.Iema.I49.MXN9 _CKGEN.IEMA.I49.NET049 GTPSA_SPLIT VSSE VPW N11LL_CKT
+  W=0.4U L=0.04U
X_M_ckgen.Iema.I49.MXP0 _CKGEN.IEMA.I49.NDIN GTPSA_SPLIT VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_ckgen.Iema.I49.MXP1 _CKGEN.IEMA.NET65 _CKGEN.IEMA.I49.NDIN
+  _CKGEN.IEMA.I49.NET044 VNWP P11LL_CKT W=0.4U L=0.04U
X_M_ckgen.Iema.I49.MXP2 _CKGEN.IEMA.I49.NET044 _CKGEN.IEMA.I49.NDIN VDDPE VNWP
+  P11LL_CKT W=0.4U L=0.04U
X_M_ckgen.Iema.Irmux.I61.MXNA1 _CKGEN.IEMA.NCK_IN SAE_DUMMY VSSE VPW N11LL_CKT
+  W=1.03U L=0.04U
X_M_ckgen.Iema.Irmux.I61.MXPA1 _CKGEN.IEMA.NCK_IN SAE_DUMMY VDDPE VNWP
+  P11LL_CKT W=1.53U L=0.04U
X_M_ckgen.Iema.Irmux._rdly0.MXN3 _CKGEN.IEMA.IRMUX._RDLY0.NET40
+  _CKGEN.IEMA.IRMUX.CKMX1O _CKGEN.IEMA.IRMUX._RDLY0.NET045 VPW N11LL_CKT
+  W=0.57U L=0.04U
X_M_ckgen.Iema.Irmux._rdly0.MXN4 _CKGEN.IEMA.IRMUX.CKDLY0
+  _CKGEN.IEMA.IRMUX._RDLY0.NDIN VSSE VPW N11LL_CKT W=0.57U L=0.04U
X_M_ckgen.Iema.Irmux._rdly0.MXN8 _CKGEN.IEMA.IRMUX._RDLY0.NDIN
+  _CKGEN.IEMA.IRMUX.CKMX1O _CKGEN.IEMA.IRMUX._RDLY0.NET40 VPW N11LL_CKT
+  W=0.57U L=0.04U
X_M_ckgen.Iema.Irmux._rdly0.MXN9 _CKGEN.IEMA.IRMUX._RDLY0.NET045
+  _CKGEN.IEMA.IRMUX.CKMX1O VSSE VPW N11LL_CKT W=0.57U L=0.04U
X_M_ckgen.Iema.Irmux._rdly0.MXP0 _CKGEN.IEMA.IRMUX._RDLY0.NDIN
+  _CKGEN.IEMA.IRMUX.CKMX1O VDDPE VNWP P11LL_CKT W=0.565U L=0.04U
X_M_ckgen.Iema.Irmux._rdly0.MXP2 _CKGEN.IEMA.IRMUX._RDLY0.NET030
+  _CKGEN.IEMA.IRMUX._RDLY0.NDIN VDDPE VNWP P11LL_CKT W=0.565U L=0.04U
X_M_ckgen.Iema.Irmux._rdly0.MXP4 _CKGEN.IEMA.IRMUX.CKDLY0
+  _CKGEN.IEMA.IRMUX._RDLY0.NDIN _CKGEN.IEMA.IRMUX._RDLY0.NET030 VNWP
+  P11LL_CKT W=0.565U L=0.04U
X_M_ckgen.Iema.Irmux._rdly1.MXN3 _CKGEN.IEMA.IRMUX._RDLY1.NET046
+  _CKGEN.IEMA.IRMUX.CKDLY2 _CKGEN.IEMA.IRMUX._RDLY1.NET038 VPW N11LL_CKT
+  W=0.57U L=0.04U
X_M_ckgen.Iema.Irmux._rdly1.MXN4 _CKGEN.IEMA.IRMUX.CKDLY1
+  _CKGEN.IEMA.IRMUX._RDLY1.NDIN VSSE VPW N11LL_CKT W=0.57U L=0.04U
X_M_ckgen.Iema.Irmux._rdly1.MXN8 _CKGEN.IEMA.IRMUX._RDLY1.NDIN
+  _CKGEN.IEMA.IRMUX.CKDLY2 _CKGEN.IEMA.IRMUX._RDLY1.NET046 VPW N11LL_CKT
+  W=0.57U L=0.04U
X_M_ckgen.Iema.Irmux._rdly1.MXN9 _CKGEN.IEMA.IRMUX._RDLY1.NET038
+  _CKGEN.IEMA.IRMUX.CKDLY2 VSSE VPW N11LL_CKT W=0.57U L=0.04U
X_M_ckgen.Iema.Irmux._rdly1.MXP0 _CKGEN.IEMA.IRMUX._RDLY1.NDIN
+  _CKGEN.IEMA.IRMUX.CKDLY2 VDDPE VNWP P11LL_CKT W=0.57U L=0.04U
X_M_ckgen.Iema.Irmux._rdly1.MXP2 _CKGEN.IEMA.IRMUX._RDLY1.NET030
+  _CKGEN.IEMA.IRMUX._RDLY1.NDIN VDDPE VNWP P11LL_CKT W=0.77U L=0.04U
X_M_ckgen.Iema.Irmux._rdly1.MXP4 _CKGEN.IEMA.IRMUX.CKDLY1
+  _CKGEN.IEMA.IRMUX._RDLY1.NDIN _CKGEN.IEMA.IRMUX._RDLY1.NET030 VNWP
+  P11LL_CKT W=0.77U L=0.04U
X_M_ckgen.Iema.Irmux._rdly2.MXN3 _CKGEN.IEMA.IRMUX._RDLY2.NET046 SAE_DUMMY
+  _CKGEN.IEMA.IRMUX._RDLY2.NET038 VPW N11LL_CKT W=0.57U L=0.04U
X_M_ckgen.Iema.Irmux._rdly2.MXN4 _CKGEN.IEMA.IRMUX.CKDLY2
+  _CKGEN.IEMA.IRMUX._RDLY2.NDIN VSSE VPW N11LL_CKT W=0.57U L=0.04U
X_M_ckgen.Iema.Irmux._rdly2.MXN8 _CKGEN.IEMA.IRMUX._RDLY2.NDIN SAE_DUMMY
+  _CKGEN.IEMA.IRMUX._RDLY2.NET046 VPW N11LL_CKT W=0.57U L=0.04U
X_M_ckgen.Iema.Irmux._rdly2.MXN9 _CKGEN.IEMA.IRMUX._RDLY2.NET038 SAE_DUMMY
+  VSSE VPW N11LL_CKT W=0.57U L=0.04U
X_M_ckgen.Iema.Irmux._rdly2.MXP0 _CKGEN.IEMA.IRMUX._RDLY2.NDIN SAE_DUMMY VDDPE
+  VNWP P11LL_CKT W=0.57U L=0.04U
X_M_ckgen.Iema.Irmux._rdly2.MXP2 _CKGEN.IEMA.IRMUX._RDLY2.NET030
+  _CKGEN.IEMA.IRMUX._RDLY2.NDIN VDDPE VNWP P11LL_CKT W=0.77U L=0.04U
X_M_ckgen.Iema.Irmux._rdly2.MXP4 _CKGEN.IEMA.IRMUX.CKDLY2
+  _CKGEN.IEMA.IRMUX._RDLY2.NDIN _CKGEN.IEMA.IRMUX._RDLY2.NET030 VNWP
+  P11LL_CKT W=0.77U L=0.04U
X_M_ckgen.Iema.Irmux._rmx0.I12.MXNA1 _CKGEN.IEMA.IRMUX._RMX0.A0
+  _CKGEN.IEMA.IRMUX.CKMX1O _CKGEN.IEMA.IRMUX._RMX0.I12.N1 VPW N11LL_CKT
+  W=0.425U L=0.04U
X_M_ckgen.Iema.Irmux._rmx0.I12.MXNA2 _CKGEN.IEMA.IRMUX._RMX0.I12.N1
+  _CKGEN.IEMA.IRMUX._RMX0.SEL_IN VSSE VPW N11LL_CKT W=0.425U L=0.04U
X_M_ckgen.Iema.Irmux._rmx0.I12.MXPA1 _CKGEN.IEMA.IRMUX._RMX0.A0
+  _CKGEN.IEMA.IRMUX.CKMX1O VDDPE VNWP P11LL_CKT W=0.425U L=0.04U
X_M_ckgen.Iema.Irmux._rmx0.I12.MXPA2 _CKGEN.IEMA.IRMUX._RMX0.A0
+  _CKGEN.IEMA.IRMUX._RMX0.SEL_IN VDDPE VNWP P11LL_CKT W=0.425U L=0.04U
X_M_ckgen.Iema.Irmux._rmx0.I13.MXNA1 _CKGEN.IEMA.IRMUX._RMX0.A1
+  _CKGEN.IEMA.IRMUX.CKDLY0 _CKGEN.IEMA.IRMUX._RMX0.I13.N1 VPW N11LL_CKT
+  W=0.425U L=0.04U
X_M_ckgen.Iema.Irmux._rmx0.I13.MXNA2 _CKGEN.IEMA.IRMUX._RMX0.I13.N1 EMA[0]
+  VSSE VPW N11LL_CKT W=0.425U L=0.04U
X_M_ckgen.Iema.Irmux._rmx0.I13.MXPA1 _CKGEN.IEMA.IRMUX._RMX0.A1
+  _CKGEN.IEMA.IRMUX.CKDLY0 VDDPE VNWP P11LL_CKT W=0.425U L=0.04U
X_M_ckgen.Iema.Irmux._rmx0.I13.MXPA2 _CKGEN.IEMA.IRMUX._RMX0.A1 EMA[0] VDDPE
+  VNWP P11LL_CKT W=0.425U L=0.04U
X_M_ckgen.Iema.Irmux._rmx0.I18.MXNA1 _CKGEN.IEMA.IRMUX.NET67
+  _CKGEN.IEMA.IRMUX._RMX0.A0 _CKGEN.IEMA.IRMUX._RMX0.I18.A1A2 VPW N11LL_CKT
+  W=0.425U L=0.04U
X_M_ckgen.Iema.Irmux._rmx0.I18.MXNA2 _CKGEN.IEMA.IRMUX._RMX0.I18.A1A2
+  _CKGEN.IEMA.IRMUX._RMX0.A1 VSSE VPW N11LL_CKT W=0.425U L=0.04U
X_M_ckgen.Iema.Irmux._rmx0.I18.MXNB1 _CKGEN.IEMA.IRMUX.NET67
+  _CKGEN.IEMA.NCK_IN VSSE VPW N11LL_CKT W=0.425U L=0.04U
X_M_ckgen.Iema.Irmux._rmx0.I18.MXPA1 _CKGEN.IEMA.IRMUX.NET67
+  _CKGEN.IEMA.IRMUX._RMX0.A0 _CKGEN.IEMA.IRMUX._RMX0.I18.A1A2UP VNWP
+  P11LL_CKT W=0.85U L=0.04U
X_M_ckgen.Iema.Irmux._rmx0.I18.MXPA2 _CKGEN.IEMA.IRMUX.NET67
+  _CKGEN.IEMA.IRMUX._RMX0.A1 _CKGEN.IEMA.IRMUX._RMX0.I18.A1A2UP VNWP
+  P11LL_CKT W=0.85U L=0.04U
X_M_ckgen.Iema.Irmux._rmx0.I18.MXPB1 _CKGEN.IEMA.IRMUX._RMX0.I18.A1A2UP
+  _CKGEN.IEMA.NCK_IN VDDPE VNWP P11LL_CKT W=0.85U L=0.04U
X_M_ckgen.Iema.Irmux._rmx0.I2.MXNA1 _CKGEN.IEMA.IRMUX._RMX0.SEL_IN EMA[0] VSSE
+  VPW N11LL_CKT W=0.15U L=0.04U
X_M_ckgen.Iema.Irmux._rmx0.I2.MXPA1 _CKGEN.IEMA.IRMUX._RMX0.SEL_IN EMA[0]
+  VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_M_ckgen.Iema.Irmux._rmx00.I19.MXNA1 _CKGEN.IEMA.IRMUX._RMX00.NCK_IN
+  SAE_DUMMY VSSE VPW N11LL_CKT W=0.2U L=0.04U
X_M_ckgen.Iema.Irmux._rmx00.I19.MXPA1 _CKGEN.IEMA.IRMUX._RMX00.NCK_IN
+  SAE_DUMMY VDDPE VNWP P11LL_CKT W=0.56U L=0.04U
X_M_ckgen.Iema.Irmux._rmx00.I2.MXNA1 _CKGEN.IEMA.IRMUX._RMX00.SEL_IN EMA[2]
+  VSSE VPW N11LL_CKT W=0.145U L=0.04U
X_M_ckgen.Iema.Irmux._rmx00.I2.MXPA1 _CKGEN.IEMA.IRMUX._RMX00.SEL_IN EMA[2]
+  VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_M_ckgen.Iema.Irmux._rmx00.I20.MXNA1 _CKGEN.IEMA.IRMUX._RMX00.NCK_DLY
+  _CKGEN.IEMA.IRMUX.NET67 VSSE VPW N11LL_CKT W=0.425U L=0.04U
X_M_ckgen.Iema.Irmux._rmx00.I20.MXPA1 _CKGEN.IEMA.IRMUX._RMX00.NCK_DLY
+  _CKGEN.IEMA.IRMUX.NET67 VDDPE VNWP P11LL_CKT W=0.56U L=0.04U
X_M_ckgen.Iema.Irmux._rmx00.I21.MXNOE _CKGEN.IEMA.IRMUX._RMX00.NCK_OUT
+  _CKGEN.IEMA.IRMUX._RMX00.SEL_IN _CKGEN.IEMA.IRMUX._RMX00.NCK_IN VPW
+  N11LL_CKT W=0.3U L=0.04U
X_M_ckgen.Iema.Irmux._rmx00.I21.MXPOEN _CKGEN.IEMA.IRMUX._RMX00.NCK_OUT EMA[2]
+  _CKGEN.IEMA.IRMUX._RMX00.NCK_IN VNWP P11LL_CKT W=0.48U L=0.04U
X_M_ckgen.Iema.Irmux._rmx00.I22.MXNOE _CKGEN.IEMA.IRMUX._RMX00.NCK_OUT EMA[2]
+  _CKGEN.IEMA.IRMUX._RMX00.NCK_DLY VPW N11LL_CKT W=0.3U L=0.04U
X_M_ckgen.Iema.Irmux._rmx00.I22.MXPOEN _CKGEN.IEMA.IRMUX._RMX00.NCK_OUT
+  _CKGEN.IEMA.IRMUX._RMX00.SEL_IN _CKGEN.IEMA.IRMUX._RMX00.NCK_DLY VNWP
+  P11LL_CKT W=0.48U L=0.04U
X_M_ckgen.Iema.Irmux._rmx00.I23.MXNA1 GTPSA_SPLIT
+  _CKGEN.IEMA.IRMUX._RMX00.NCK_OUT VSSE VPW N11LL_CKT W=0.936U L=0.04U
X_M_ckgen.Iema.Irmux._rmx00.I23.MXPA1 GTPSA_SPLIT
+  _CKGEN.IEMA.IRMUX._RMX00.NCK_OUT VDDPE VNWP P11LL_CKT W=1.42U L=0.04U
X_M_ckgen.Iema.Irmux._rmx1.I19.MXNA1 _CKGEN.IEMA.IRMUX._RMX1.NCK_IN SAE_DUMMY
+  VSSE VPW N11LL_CKT W=0.425U L=0.04U
X_M_ckgen.Iema.Irmux._rmx1.I19.MXPA1 _CKGEN.IEMA.IRMUX._RMX1.NCK_IN SAE_DUMMY
+  VDDPE VNWP P11LL_CKT W=0.51U L=0.04U
X_M_ckgen.Iema.Irmux._rmx1.I2.MXNA1 _CKGEN.IEMA.IRMUX._RMX1.SEL_IN EMA[1] VSSE
+  VPW N11LL_CKT W=0.15U L=0.04U
X_M_ckgen.Iema.Irmux._rmx1.I2.MXPA1 _CKGEN.IEMA.IRMUX._RMX1.SEL_IN EMA[1]
+  VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_M_ckgen.Iema.Irmux._rmx1.I20.MXNA1 _CKGEN.IEMA.IRMUX._RMX1.NCK_DLY
+  _CKGEN.IEMA.IRMUX.CKDLY1 VSSE VPW N11LL_CKT W=0.425U L=0.04U
X_M_ckgen.Iema.Irmux._rmx1.I20.MXPA1 _CKGEN.IEMA.IRMUX._RMX1.NCK_DLY
+  _CKGEN.IEMA.IRMUX.CKDLY1 VDDPE VNWP P11LL_CKT W=0.51U L=0.04U
X_M_ckgen.Iema.Irmux._rmx1.I21.MXNOE _CKGEN.IEMA.IRMUX._RMX1.NCK_OUT
+  _CKGEN.IEMA.IRMUX._RMX1.SEL_IN _CKGEN.IEMA.IRMUX._RMX1.NCK_IN VPW N11LL_CKT
+  W=0.425U L=0.04U
X_M_ckgen.Iema.Irmux._rmx1.I21.MXPOEN _CKGEN.IEMA.IRMUX._RMX1.NCK_OUT EMA[1]
+  _CKGEN.IEMA.IRMUX._RMX1.NCK_IN VNWP P11LL_CKT W=0.425U L=0.04U
X_M_ckgen.Iema.Irmux._rmx1.I22.MXNOE _CKGEN.IEMA.IRMUX._RMX1.NCK_OUT EMA[1]
+  _CKGEN.IEMA.IRMUX._RMX1.NCK_DLY VPW N11LL_CKT W=0.425U L=0.04U
X_M_ckgen.Iema.Irmux._rmx1.I22.MXPOEN _CKGEN.IEMA.IRMUX._RMX1.NCK_OUT
+  _CKGEN.IEMA.IRMUX._RMX1.SEL_IN _CKGEN.IEMA.IRMUX._RMX1.NCK_DLY VNWP
+  P11LL_CKT W=0.425U L=0.04U
X_M_ckgen.Iema.Irmux._rmx1.I23.MXNA1 _CKGEN.IEMA.IRMUX.CKMX1O
+  _CKGEN.IEMA.IRMUX._RMX1.NCK_OUT VSSE VPW N11LL_CKT W=0.425U L=0.04U
X_M_ckgen.Iema.Irmux._rmx1.I23.MXPA1 _CKGEN.IEMA.IRMUX.CKMX1O
+  _CKGEN.IEMA.IRMUX._RMX1.NCK_OUT VDDPE VNWP P11LL_CKT W=0.595U L=0.04U
X_M_ckgen.Iema._wdly0.MXN3 _CKGEN.IEMA._WDLY0.NET057 _CKGEN.IEMA.WCLK00
+  _CKGEN.IEMA._WDLY0.NET049 VPW N11LL_CKT W=0.43U L=0.04U
X_M_ckgen.Iema._wdly0.MXN4 _CKGEN.IEMA.WCLK01 _CKGEN.IEMA._WDLY0.NDIN VSSE VPW
+  N11LL_CKT W=0.57U L=0.04U
X_M_ckgen.Iema._wdly0.MXN8 _CKGEN.IEMA._WDLY0.NDIN _CKGEN.IEMA.WCLK00
+  _CKGEN.IEMA._WDLY0.NET057 VPW N11LL_CKT W=0.43U L=0.04U
X_M_ckgen.Iema._wdly0.MXN9 _CKGEN.IEMA._WDLY0.NET049 _CKGEN.IEMA.WCLK00 VSSE
+  VPW N11LL_CKT W=0.43U L=0.04U
X_M_ckgen.Iema._wdly0.MXP0 _CKGEN.IEMA._WDLY0.NDIN _CKGEN.IEMA.WCLK00 VDDPE
+  VNWP P11LL_CKT W=0.57U L=0.04U
X_M_ckgen.Iema._wdly0.MXP1 _CKGEN.IEMA.WCLK01 _CKGEN.IEMA._WDLY0.NDIN
+  _CKGEN.IEMA._WDLY0.NET044 VNWP P11LL_CKT W=0.28U L=0.04U
X_M_ckgen.Iema._wdly0.MXP2 _CKGEN.IEMA._WDLY0.NET044 _CKGEN.IEMA._WDLY0.NDIN
+  VDDPE VNWP P11LL_CKT W=0.28U L=0.04U
X_M_ckgen.Iema._wdly1.MXN3 _CKGEN.IEMA._WDLY1.NET057 _CKGEN.IEMA.DWCLK10
+  _CKGEN.IEMA._WDLY1.NET049 VPW N11LL_CKT W=0.43U L=0.04U
X_M_ckgen.Iema._wdly1.MXN4 _CKGEN.IEMA.WCLK11 _CKGEN.IEMA._WDLY1.NDIN VSSE VPW
+  N11LL_CKT W=0.57U L=0.04U
X_M_ckgen.Iema._wdly1.MXN8 _CKGEN.IEMA._WDLY1.NDIN _CKGEN.IEMA.DWCLK10
+  _CKGEN.IEMA._WDLY1.NET057 VPW N11LL_CKT W=0.43U L=0.04U
X_M_ckgen.Iema._wdly1.MXN9 _CKGEN.IEMA._WDLY1.NET049 _CKGEN.IEMA.DWCLK10 VSSE
+  VPW N11LL_CKT W=0.43U L=0.04U
X_M_ckgen.Iema._wdly1.MXP0 _CKGEN.IEMA._WDLY1.NDIN _CKGEN.IEMA.DWCLK10 VDDPE
+  VNWP P11LL_CKT W=0.57U L=0.04U
X_M_ckgen.Iema._wdly1.MXP1 _CKGEN.IEMA.WCLK11 _CKGEN.IEMA._WDLY1.NDIN
+  _CKGEN.IEMA._WDLY1.NET044 VNWP P11LL_CKT W=0.28U L=0.04U
X_M_ckgen.Iema._wdly1.MXP2 _CKGEN.IEMA._WDLY1.NET044 _CKGEN.IEMA._WDLY1.NDIN
+  VDDPE VNWP P11LL_CKT W=0.28U L=0.04U
X_M_ckgen.Iema._wdly2.MXN3 _CKGEN.IEMA._WDLY2.NET057 _CKGEN.IEMA.NET65
+  _CKGEN.IEMA._WDLY2.NET049 VPW N11LL_CKT W=0.43U L=0.04U
X_M_ckgen.Iema._wdly2.MXN4 _CKGEN.IEMA.DWCLK10 _CKGEN.IEMA._WDLY2.NDIN VSSE
+  VPW N11LL_CKT W=0.57U L=0.04U
X_M_ckgen.Iema._wdly2.MXN8 _CKGEN.IEMA._WDLY2.NDIN _CKGEN.IEMA.NET65
+  _CKGEN.IEMA._WDLY2.NET057 VPW N11LL_CKT W=0.43U L=0.04U
X_M_ckgen.Iema._wdly2.MXN9 _CKGEN.IEMA._WDLY2.NET049 _CKGEN.IEMA.NET65 VSSE
+  VPW N11LL_CKT W=0.43U L=0.04U
X_M_ckgen.Iema._wdly2.MXP0 _CKGEN.IEMA._WDLY2.NDIN _CKGEN.IEMA.NET65 VDDPE
+  VNWP P11LL_CKT W=0.57U L=0.04U
X_M_ckgen.Iema._wdly2.MXP1 _CKGEN.IEMA.DWCLK10 _CKGEN.IEMA._WDLY2.NDIN
+  _CKGEN.IEMA._WDLY2.NET044 VNWP P11LL_CKT W=0.28U L=0.04U
X_M_ckgen.Iema._wdly2.MXP2 _CKGEN.IEMA._WDLY2.NET044 _CKGEN.IEMA._WDLY2.NDIN
+  VDDPE VNWP P11LL_CKT W=0.28U L=0.04U
X_M_ckgen.Iema._wmx0.I12.MXNA1 _CKGEN.IEMA._WMX0.A0 _CKGEN.IEMA.WCLK00
+  _CKGEN.IEMA._WMX0.I12.N1 VPW N11LL_CKT W=0.425U L=0.04U
X_M_ckgen.Iema._wmx0.I12.MXNA2 _CKGEN.IEMA._WMX0.I12.N1
+  _CKGEN.IEMA._WMX0.SEL_IN VSSE VPW N11LL_CKT W=0.425U L=0.04U
X_M_ckgen.Iema._wmx0.I12.MXPA1 _CKGEN.IEMA._WMX0.A0 _CKGEN.IEMA.WCLK00 VDDPE
+  VNWP P11LL_CKT W=0.43U L=0.04U
X_M_ckgen.Iema._wmx0.I12.MXPA2 _CKGEN.IEMA._WMX0.A0 _CKGEN.IEMA._WMX0.SEL_IN
+  VDDPE VNWP P11LL_CKT W=0.43U L=0.04U
X_M_ckgen.Iema._wmx0.I13.MXNA1 _CKGEN.IEMA._WMX0.A1 _CKGEN.IEMA.WCLK01
+  _CKGEN.IEMA._WMX0.I13.N1 VPW N11LL_CKT W=0.425U L=0.04U
X_M_ckgen.Iema._wmx0.I13.MXNA2 _CKGEN.IEMA._WMX0.I13.N1 EMAW[0] VSSE VPW
+  N11LL_CKT W=0.425U L=0.04U
X_M_ckgen.Iema._wmx0.I13.MXPA1 _CKGEN.IEMA._WMX0.A1 _CKGEN.IEMA.WCLK01 VDDPE
+  VNWP P11LL_CKT W=0.43U L=0.04U
X_M_ckgen.Iema._wmx0.I13.MXPA2 _CKGEN.IEMA._WMX0.A1 EMAW[0] VDDPE VNWP
+  P11LL_CKT W=0.43U L=0.04U
X_M_ckgen.Iema._wmx0.I18.MXNA1 _CKGEN.IEMA.WDLY _CKGEN.IEMA._WMX0.A0
+  _CKGEN.IEMA._WMX0.I18.A1A2 VPW N11LL_CKT W=0.425U L=0.04U
X_M_ckgen.Iema._wmx0.I18.MXNA2 _CKGEN.IEMA._WMX0.I18.A1A2 _CKGEN.IEMA._WMX0.A1
+  VSSE VPW N11LL_CKT W=0.425U L=0.04U
X_M_ckgen.Iema._wmx0.I18.MXNB1 _CKGEN.IEMA.WDLY _CKGEN.IEMA.NCK_IN VSSE VPW
+  N11LL_CKT W=0.425U L=0.04U
X_M_ckgen.Iema._wmx0.I18.MXPA1 _CKGEN.IEMA.WDLY _CKGEN.IEMA._WMX0.A0
+  _CKGEN.IEMA._WMX0.I18.A1A2UP VNWP P11LL_CKT W=0.85U L=0.04U
X_M_ckgen.Iema._wmx0.I18.MXPA2 _CKGEN.IEMA.WDLY _CKGEN.IEMA._WMX0.A1
+  _CKGEN.IEMA._WMX0.I18.A1A2UP VNWP P11LL_CKT W=0.85U L=0.04U
X_M_ckgen.Iema._wmx0.I18.MXPB1 _CKGEN.IEMA._WMX0.I18.A1A2UP _CKGEN.IEMA.NCK_IN
+  VDDPE VNWP P11LL_CKT W=0.85U L=0.04U
X_M_ckgen.Iema._wmx0.I2.MXNA1 _CKGEN.IEMA._WMX0.SEL_IN EMAW[0] VSSE VPW
+  N11LL_CKT W=0.15U L=0.04U
X_M_ckgen.Iema._wmx0.I2.MXPA1 _CKGEN.IEMA._WMX0.SEL_IN EMAW[0] VDDPE VNWP
+  P11LL_CKT W=0.17U L=0.04U
X_M_ckgen.Iema._wmx1.I19.MXNA1 _CKGEN.IEMA._WMX1.NCK_IN _CKGEN.IEMA.NET65 VSSE
+  VPW N11LL_CKT W=0.425U L=0.04U
X_M_ckgen.Iema._wmx1.I19.MXPA1 _CKGEN.IEMA._WMX1.NCK_IN _CKGEN.IEMA.NET65
+  VDDPE VNWP P11LL_CKT W=0.51U L=0.04U
X_M_ckgen.Iema._wmx1.I2.MXNA1 _CKGEN.IEMA._WMX1.SEL_IN EMAW[1] VSSE VPW
+  N11LL_CKT W=0.15U L=0.04U
X_M_ckgen.Iema._wmx1.I2.MXPA1 _CKGEN.IEMA._WMX1.SEL_IN EMAW[1] VDDPE VNWP
+  P11LL_CKT W=0.17U L=0.04U
X_M_ckgen.Iema._wmx1.I20.MXNA1 _CKGEN.IEMA._WMX1.NCK_DLY _CKGEN.IEMA.WCLK11
+  VSSE VPW N11LL_CKT W=0.425U L=0.04U
X_M_ckgen.Iema._wmx1.I20.MXPA1 _CKGEN.IEMA._WMX1.NCK_DLY _CKGEN.IEMA.WCLK11
+  VDDPE VNWP P11LL_CKT W=0.51U L=0.04U
X_M_ckgen.Iema._wmx1.I21.MXNOE _CKGEN.IEMA._WMX1.NCK_OUT
+  _CKGEN.IEMA._WMX1.SEL_IN _CKGEN.IEMA._WMX1.NCK_IN VPW N11LL_CKT W=0.425U
+  L=0.04U
X_M_ckgen.Iema._wmx1.I21.MXPOEN _CKGEN.IEMA._WMX1.NCK_OUT EMAW[1]
+  _CKGEN.IEMA._WMX1.NCK_IN VNWP P11LL_CKT W=0.425U L=0.04U
X_M_ckgen.Iema._wmx1.I22.MXNOE _CKGEN.IEMA._WMX1.NCK_OUT EMAW[1]
+  _CKGEN.IEMA._WMX1.NCK_DLY VPW N11LL_CKT W=0.425U L=0.04U
X_M_ckgen.Iema._wmx1.I22.MXPOEN _CKGEN.IEMA._WMX1.NCK_OUT
+  _CKGEN.IEMA._WMX1.SEL_IN _CKGEN.IEMA._WMX1.NCK_DLY VNWP P11LL_CKT W=0.425U
+  L=0.04U
X_M_ckgen.Iema._wmx1.I23.MXNA1 _CKGEN.IEMA.WCLK00 _CKGEN.IEMA._WMX1.NCK_OUT
+  VSSE VPW N11LL_CKT W=0.425U L=0.04U
X_M_ckgen.Iema._wmx1.I23.MXPA1 _CKGEN.IEMA.WCLK00 _CKGEN.IEMA._WMX1.NCK_OUT
+  VDDPE VNWP P11LL_CKT W=0.595U L=0.04U
X_M_ckgen._memgtp.I1.MXNA1 _CKGEN._MEMGTP.C1 _CKGEN._MEMGTP.NCLK
+  _CKGEN._MEMGTP.I1.N1 VPW N11LL_CKT W=0.145U L=0.04U
X_M_ckgen._memgtp.I1.MXNA2 _CKGEN._MEMGTP.I1.N1 RET1N VSSE VPW N11LL_CKT
+  W=0.145U L=0.04U
X_M_ckgen._memgtp.I1.MXPA1 _CKGEN._MEMGTP.C1 _CKGEN._MEMGTP.NCLK VDDPE VNWP
+  P11LL_CKT W=0.145U L=0.04U
X_M_ckgen._memgtp.I1.MXPA2 _CKGEN._MEMGTP.C1 RET1N VDDPE VNWP P11LL_CKT
+  W=0.145U L=0.04U
X_M_ckgen._memgtp.I24.MXNA1 _CKGEN._MEMGTP.C2 CEN _CKGEN._MEMGTP.I24.A1A2 VPW
+  N11LL_CKT W=0.285U L=0.04U
X_M_ckgen._memgtp.I24.MXNA2 _CKGEN._MEMGTP.I24.A1A2 _CKGEN._MEMGTP.NDFT VSSE
+  VPW N11LL_CKT W=0.285U L=0.04U
X_M_ckgen._memgtp.I24.MXNB1 _CKGEN._MEMGTP.C2 _CKGEN._MEMGTP.C1 VSSE VPW
+  N11LL_CKT W=0.145U L=0.04U
X_M_ckgen._memgtp.I24.MXPA1 _CKGEN._MEMGTP.C2 CEN _CKGEN._MEMGTP.I24.A1A2UP
+  VNWP P11LL_CKT W=0.565U L=0.04U
X_M_ckgen._memgtp.I24.MXPA2 _CKGEN._MEMGTP.C2 _CKGEN._MEMGTP.NDFT
+  _CKGEN._MEMGTP.I24.A1A2UP VNWP P11LL_CKT W=0.565U L=0.04U
X_M_ckgen._memgtp.I24.MXPB1 _CKGEN._MEMGTP.I24.A1A2UP _CKGEN._MEMGTP.C1 VDDPE
+  VNWP P11LL_CKT W=0.565U L=0.04U
X_M_ckgen._memgtp.I6.MXNA1 GTP _CKGEN.NGTP VSSE VPW N11LL_CKT W=5.685U L=0.04U
X_M_ckgen._memgtp.I6.MXPA1 GTP _CKGEN.NGTP VDDPE VNWP P11LL_CKT W=11.37U
+  L=0.04U
X_M_ckgen._memgtp.I68.MXNA1 _CKGEN._MEMGTP.FEED _CKGEN.NGTP VSSE VPW N11LL_CKT
+  W=0.285U L=0.04U
X_M_ckgen._memgtp.I68.MXPA1 _CKGEN._MEMGTP.FEED _CKGEN.NGTP VDDPE VNWP
+  P11LL_CKT W=0.72U L=0.04U
X_M_ckgen._memgtp.I7.MXNA1 _CKGEN._MEMGTP.NCLK CLK VSS VPW N11LL_CKT W=4.26U
+  L=0.04U
X_M_ckgen._memgtp.I7.MXPA1 _CKGEN._MEMGTP.NCLK CLK VDDPE VNWP P11LL_CKT
+  W=4.26U L=0.04U
X_M_ckgen._memgtp.I74.MXNA1 _CKGEN.NET035 _CKGEN._MEMGTP.FEED VSSE VPW
+  N11LL_CKT W=0.31U L=0.04U
X_M_ckgen._memgtp.I74.MXPA1 _CKGEN.NET035 _CKGEN._MEMGTP.FEED VDDPE VNWP
+  P11LL_CKT W=0.43U L=0.04U
X_M_ckgen._memgtp.I82.MXNA1 _CKGEN._MEMGTP.CTR _CKGEN._MEMGTP.C3 VSSE VPW
+  N11LL_CKT W=0.71U L=0.04U
X_M_ckgen._memgtp.I82.MXPA1 _CKGEN._MEMGTP.CTR _CKGEN._MEMGTP.C3 VDDPE VNWP
+  P11LL_CKT W=1.7U L=0.04U
X_M_ckgen._memgtp.I83.MXNA1 _CKGEN._MEMGTP.C3 _CKGEN._MEMGTP.C2
+  _CKGEN._MEMGTP.I83.N1 VPW N11LL_CKT W=0.71U L=0.04U
X_M_ckgen._memgtp.I83.MXNA2 _CKGEN._MEMGTP.I83.N1 _CKGEN.NET035 VSSE VPW
+  N11LL_CKT W=0.71U L=0.04U
X_M_ckgen._memgtp.I83.MXPA1 _CKGEN._MEMGTP.C3 _CKGEN._MEMGTP.C2 VDDPE VNWP
+  P11LL_CKT W=0.425U L=0.04U
X_M_ckgen._memgtp.I83.MXPA2 _CKGEN._MEMGTP.C3 _CKGEN.NET035 VDDPE VNWP
+  P11LL_CKT W=0.425U L=0.04U
X_M_ckgen._memgtp.I86.MXNA1 _CKGEN._MEMGTP.NDFT LOG0 VSS VPW N11LL_CKT
+  W=0.145U L=0.04U
X_M_ckgen._memgtp.I86.MXPA1 _CKGEN._MEMGTP.NDFT LOG0 VDDPE VNWP P11LL_CKT
+  W=0.145U L=0.04U
X_M_ckgen._memgtp.MXN0 _CKGEN._MEMGTP.NCLK _CKGEN._MEMGTP.CTR _CKGEN.NGTP VPW
+  N11LL_CKT W=4.25U L=0.04U
X_M_ckgen._memgtp.MXN7 _CKGEN.NGTP _CKGEN._MEMGTP.FEED _CKGEN._MEMGTP.NET114
+  VPW N11LL_CKT W=0.26U L=0.04U
X_M_ckgen._memgtp.MXN8 _CKGEN._MEMGTP.NET114 _CKGEN.RESET VSSE VPW N11LL_CKT
+  W=0.26U L=0.04U
X_M_ckgen._memgtp.MXP1 _CKGEN.NGTP _CKGEN.RESET VDDPE VNWP P11LL_CKT W=4.275U
+  L=0.04U
X_M_ckgen._memgtp.MXP2 _CKGEN._MEMGTP.NET127 _CKGEN._MEMGTP.CTR VDDPE VNWP
+  P11LL_CKT W=0.48U L=0.04U
X_M_ckgen._memgtp.MXP3 _CKGEN._MEMGTP.NET127 CLK VDDPE VNWP P11LL_CKT W=0.48U
+  L=0.04U
X_M_ckgen._memgtp.MXP5 _CKGEN.NGTP _CKGEN._MEMGTP.FEED _CKGEN._MEMGTP.NET127
+  VNWP P11LL_CKT W=0.48U L=0.04U
X_M_gwen_lat.I47.MXNA1 _GWEN_LAT.ND GWEN VSS VPW N11LL_CKT W=0.34U L=0.04U
X_M_gwen_lat.I47.MXPA1 _GWEN_LAT.ND GWEN VDDPE VNWP P11LL_CKT W=0.68U L=0.04U
X_M_gwen_lat.I48.MXNOE GWEN_LAT_NQ NCLK_GTPSA _GWEN_LAT.ND VPW N11LL_CKT
+  W=0.34U L=0.04U
X_M_gwen_lat.I48.MXPOEN GWEN_LAT_NQ BCLK_GTPSA _GWEN_LAT.ND VNWP P11LL_CKT
+  W=0.34U L=0.04U
X_M_gwen_lat.I50.MXNA1 GWEN_LAT_Q GWEN_LAT_NQ VSS VPW N11LL_CKT W=0.4U L=0.04U
X_M_gwen_lat.I50.MXPA1 GWEN_LAT_Q GWEN_LAT_NQ VDDPE VNWP P11LL_CKT W=0.57U
+  L=0.04U
X_M_gwen_lat.I55.MXNA1 _GWEN_LAT.I55.N1 GWEN_LAT_Q VSS VPW N11LL_CKT W=0.15U
+  L=0.04U
X_M_gwen_lat.I55.MXNOE GWEN_LAT_NQ BCLK_GTPSA _GWEN_LAT.I55.N1 VPW N11LL_CKT
+  W=0.15U L=0.04U
X_M_gwen_lat.I55.MXPA1 _GWEN_LAT.I55.P1 GWEN_LAT_Q VDDPE VNWP P11LL_CKT
+  W=0.15U L=0.04U
X_M_gwen_lat.I55.MXPOEN GWEN_LAT_NQ NCLK_GTPSA _GWEN_LAT.I55.P1 VNWP P11LL_CKT
+  W=0.15U L=0.04U
X_M_rdt_lat.I47.MXNA1 _RDT_LAT.ND RDT VSS VPW N11LL_CKT W=0.34U L=0.04U
X_M_rdt_lat.I47.MXPA1 _RDT_LAT.ND RDT VDDPE VNWP P11LL_CKT W=0.68U L=0.04U
X_M_rdt_lat.I48.MXNOE NRDT_LAT NCLK _RDT_LAT.ND VPW N11LL_CKT W=0.34U L=0.04U
X_M_rdt_lat.I48.MXPOEN NRDT_LAT BCLK _RDT_LAT.ND VNWP P11LL_CKT W=0.34U
+  L=0.04U
X_M_rdt_lat.I50.MXNA1 RDT_P2 NRDT_LAT VSS VPW N11LL_CKT W=0.4U L=0.04U
X_M_rdt_lat.I50.MXPA1 RDT_P2 NRDT_LAT VDDPE VNWP P11LL_CKT W=0.57U L=0.04U
X_M_rdt_lat.I55.MXNA1 _RDT_LAT.I55.N1 RDT_P2 VSS VPW N11LL_CKT W=0.15U L=0.04U
X_M_rdt_lat.I55.MXNOE NRDT_LAT BCLK _RDT_LAT.I55.N1 VPW N11LL_CKT W=0.15U
+  L=0.04U
X_M_rdt_lat.I55.MXPA1 _RDT_LAT.I55.P1 RDT_P2 VDDPE VNWP P11LL_CKT W=0.15U
+  L=0.04U
X_M_rdt_lat.I55.MXPOEN NRDT_LAT NCLK _RDT_LAT.I55.P1 VNWP P11LL_CKT W=0.15U
+  L=0.04U
X_M_write.I14.MXNA1 NWCLK _WRITE.NET0102 VSS VPW N11LL_CKT W=5.53U L=0.04U
X_M_write.I14.MXPA1 NWCLK _WRITE.NET0102 VDDPE VNWP P11LL_CKT W=5.7U L=0.04U
X_M_write.I27.MXNA1 _WRITE.NET0102 _WRITE.NET66 VSS VPW N11LL_CKT W=0.85U
+  L=0.04U
X_M_write.I27.MXPA1 _WRITE.NET0102 _WRITE.NET66 VDDPE VNWP P11LL_CKT W=2.13U
+  L=0.04U
X_M_write.I52.MXNA1 NWCLK_WT GTP _WRITE.I52.N2 VPW N11LL_CKT W=0.595U L=0.04U
X_M_write.I52.MXNA2 _WRITE.I52.N2 GWE_DFT _WRITE.I52.N1 VPW N11LL_CKT W=0.595U
+  L=0.04U
X_M_write.I52.MXNA3 _WRITE.I52.N1 _WRITE.NET076 VSS VPW N11LL_CKT W=0.595U
+  L=0.04U
X_M_write.I52.MXPA1 NWCLK_WT GTP VDDPE VNWP P11LL_CKT W=0.51U L=0.04U
X_M_write.I52.MXPA2 NWCLK_WT GWE_DFT VDDPE VNWP P11LL_CKT W=0.51U L=0.04U
X_M_write.I52.MXPA3 NWCLK_WT _WRITE.NET076 VDDPE VNWP P11LL_CKT W=0.51U
+  L=0.04U
X_M_write.I53.MXNA1 _WRITE.NET66 GTP _WRITE.I53.NET39 VPW N11LL_CKT W=0.565U
+  L=0.04U
X_M_write.I53.MXNA2 _WRITE.NET66 _WRITE.DGTP _WRITE.I53.NET39 VPW N11LL_CKT
+  W=0.565U L=0.04U
X_M_write.I53.MXNB1 _WRITE.I53.NET39 GWE_DFT VSS VPW N11LL_CKT W=0.565U
+  L=0.04U
X_M_write.I53.MXPA1 _WRITE.NET66 GTP _WRITE.I53.P1 VNWP P11LL_CKT W=0.855U
+  L=0.04U
X_M_write.I53.MXPA2 _WRITE.I53.P1 _WRITE.DGTP VDDPE VNWP P11LL_CKT W=0.855U
+  L=0.04U
X_M_write.I53.MXPB1 _WRITE.NET66 GWE_DFT VDDPE VNWP P11LL_CKT W=0.57U L=0.04U
X_M_write.I61.MXNA1 _WRITE.NET035 LOG0 VSS VPW N11LL_CKT W=0.145U L=0.04U
X_M_write.I61.MXNA2 _WRITE.NET035 LOG0 VSS VPW N11LL_CKT W=0.145U L=0.04U
X_M_write.I61.MXPA1 _WRITE.NET035 LOG0 _WRITE.I61.P1 VNWP P11LL_CKT W=0.15U
+  L=0.04U
X_M_write.I61.MXPA2 _WRITE.I61.P1 LOG0 VDDPE VNWP P11LL_CKT W=0.15U L=0.04U
X_M_write.I62.MXNA1 _WRITE.NET076 _WRITE.NET035 VSS VPW N11LL_CKT W=0.145U
+  L=0.04U
X_M_write.I62.MXPA1 _WRITE.NET076 _WRITE.NET035 VDDPE VNWP P11LL_CKT W=0.15U
+  L=0.04U
X_M_write.I64.MXNA1 GWE_DFT GWEN_P2 VSS VPW N11LL_CKT W=0.28U L=0.04U
X_M_write.I64.MXPA1 GWE_DFT GWEN_P2 VDDPE VNWP P11LL_CKT W=0.425U L=0.04U
X_M_write.MXN0 WRITE_NGTP DWL_DLY VSS VPW N11LL_CKT W=0.285U L=0.04U
X_M_write.MXN3 _WRITE.NET037 WRITE_NGTP VSS VPW N11LL_CKT W=0.285U L=0.04U
X_M_write.MXN8 _WRITE.DGTP WRITE_NGTP _WRITE.NET037 VPW N11LL_CKT W=0.285U
+  L=0.04U
X_M_write.MXP0 _WRITE.DGTP WRITE_NGTP VDDPE VNWP P11LL_CKT W=0.285U L=0.04U
X_M_write.MXP1 VDDPE DWL_DLY VDDPE VNWP P11LL_CKT W=0.285U L=0.04U
X_M_write.MXP2 WRITE_NGTP DWL_DLY VDDPE VNWP P11LL_CKT W=0.285U L=0.04U
X_M_ydec.I13.MXNA1 _YDEC.NGTP_DFT GTP _YDEC.I13.N1 VPW N11LL_CKT W=0.85U
+  L=0.04U
X_M_ydec.I13.MXNA2 _YDEC.I13.N1 LOG1 VSS VPW N11LL_CKT W=0.85U L=0.04U
X_M_ydec.I13.MXPA1 _YDEC.NGTP_DFT GTP VDDPE VNWP P11LL_CKT W=0.71U L=0.04U
X_M_ydec.I13.MXPA2 _YDEC.NGTP_DFT LOG1 VDDPE VNWP P11LL_CKT W=0.71U L=0.04U
X_M_ydec.I7.MXNA1 _YDEC.CLK_WR _YDEC.NGTP_DFT VSSE VPW N11LL_CKT W=0.71U
+  L=0.04U
X_M_ydec.I7.MXNA2 _YDEC.CLK_WR NGWE VSSE VPW N11LL_CKT W=0.71U L=0.04U
X_M_ydec.I7.MXPA1 _YDEC.CLK_WR _YDEC.NGTP_DFT _YDEC.I7.P1 VNWP P11LL_CKT
+  W=1.42U L=0.04U
X_M_ydec.I7.MXPA2 _YDEC.I7.P1 NGWE VDDPE VNWP P11LL_CKT W=1.42U L=0.04U
X_M_ydec.I8.MXNA1 _YDEC.CLK_RD _YDEC.NGTP_DFT VSSE VPW N11LL_CKT W=0.565U
+  L=0.04U
X_M_ydec.I8.MXNA2 _YDEC.CLK_RD GWE_P2 VSSE VPW N11LL_CKT W=0.565U L=0.04U
X_M_ydec.I8.MXPA1 _YDEC.CLK_RD _YDEC.NGTP_DFT _YDEC.I8.P1 VNWP P11LL_CKT
+  W=1.42U L=0.04U
X_M_ydec.I8.MXPA2 _YDEC.I8.P1 GWE_P2 VDDPE VNWP P11LL_CKT W=1.42U L=0.04U
X_M_ydec.I9.MXNA1 NGWE GWE_P2 VSS VPW N11LL_CKT W=0.285U L=0.04U
X_M_ydec.I9.MXPA1 NGWE GWE_P2 VDDPE VNWP P11LL_CKT W=0.425U L=0.04U
X_M_ydec._rmux_0.I39.MXNA1 NYR0 _YDEC._RMUX_0.IYP VSS VPW N11LL_CKT W=3.98U
+  L=0.04U
X_M_ydec._rmux_0.I39.MXPA1 NYR0 _YDEC._RMUX_0.IYP VDDPE VNWP P11LL_CKT W=5.54U
+  L=0.04U
X_M_ydec._rmux_0.MXN0 _YDEC._RMUX_0.INYP NCADDR0 _YDEC.RN1 VPW N11LL_CKT
+  W=0.565U L=0.04U
X_M_ydec._rmux_0.MXN1 _YDEC._RMUX_0.IYP _YDEC._RMUX_0.INYP VSSE VPW N11LL_CKT
+  W=0.71U L=0.04U
X_M_ydec._rmux_0.MXN2 _YDEC.RN1 _YDEC.CLK_RD VSS VPW N11LL_CKT W=0.565U
+  L=0.04U
X_M_ydec._rmux_0.MXP0 _YDEC._RMUX_0.INYP NCADDR0 VDDPE VNWP P11LL_CKT W=0.28U
+  L=0.04U
X_M_ydec._rmux_0.MXP1 _YDEC._RMUX_0.IYP _YDEC._RMUX_0.INYP VDDPE VNWP
+  P11LL_CKT W=1.99U L=0.04U
X_M_ydec._rmux_0.MXP2 _YDEC._RMUX_0.INYP _YDEC.CLK_RD VDDPE VNWP P11LL_CKT
+  W=0.28U L=0.04U
X_M_ydec._rmux_1.I39.MXNA1 NYR1 _YDEC._RMUX_1.IYP VSS VPW N11LL_CKT W=3.98U
+  L=0.04U
X_M_ydec._rmux_1.I39.MXPA1 NYR1 _YDEC._RMUX_1.IYP VDDPE VNWP P11LL_CKT W=5.54U
+  L=0.04U
X_M_ydec._rmux_1.MXN0 _YDEC._RMUX_1.INYP CADDR0 _YDEC.RN1 VPW N11LL_CKT
+  W=0.565U L=0.04U
X_M_ydec._rmux_1.MXN1 _YDEC._RMUX_1.IYP _YDEC._RMUX_1.INYP VSSE VPW N11LL_CKT
+  W=0.71U L=0.04U
X_M_ydec._rmux_1.MXN2 _YDEC.RN1 _YDEC.CLK_RD VSS VPW N11LL_CKT W=0.565U
+  L=0.04U
X_M_ydec._rmux_1.MXP0 _YDEC._RMUX_1.INYP CADDR0 VDDPE VNWP P11LL_CKT W=0.28U
+  L=0.04U
X_M_ydec._rmux_1.MXP1 _YDEC._RMUX_1.IYP _YDEC._RMUX_1.INYP VDDPE VNWP
+  P11LL_CKT W=1.99U L=0.04U
X_M_ydec._rmux_1.MXP2 _YDEC._RMUX_1.INYP _YDEC.CLK_RD VDDPE VNWP P11LL_CKT
+  W=0.28U L=0.04U
X_M_ydec._wmux_0.MXN0 _YDEC._WMUX_0.INYP NCADDR0 _YDEC.WN1 VPW N11LL_CKT
+  W=0.995U L=0.04U
X_M_ydec._wmux_0.MXN1 YW0 _YDEC._WMUX_0.INYP VSSE VPW N11LL_CKT W=3.18U
+  L=0.04U
X_M_ydec._wmux_0.MXN2 _YDEC.WN1 _YDEC.CLK_WR VSS VPW N11LL_CKT W=0.995U
+  L=0.04U
X_M_ydec._wmux_0.MXP0 _YDEC._WMUX_0.INYP NCADDR0 VDDPE VNWP P11LL_CKT W=0.425U
+  L=0.04U
X_M_ydec._wmux_0.MXP1 YW0 _YDEC._WMUX_0.INYP VDDPE VNWP P11LL_CKT W=7.94U
+  L=0.04U
X_M_ydec._wmux_0.MXP2 _YDEC._WMUX_0.INYP _YDEC.CLK_WR VDDPE VNWP P11LL_CKT
+  W=0.95U L=0.04U
X_M_ydec._wmux_1.MXN0 _YDEC._WMUX_1.INYP CADDR0 _YDEC.WN1 VPW N11LL_CKT
+  W=0.995U L=0.04U
X_M_ydec._wmux_1.MXN1 YW1 _YDEC._WMUX_1.INYP VSSE VPW N11LL_CKT W=3.18U
+  L=0.04U
X_M_ydec._wmux_1.MXN2 _YDEC.WN1 _YDEC.CLK_WR VSS VPW N11LL_CKT W=0.995U
+  L=0.04U
X_M_ydec._wmux_1.MXP0 _YDEC._WMUX_1.INYP CADDR0 VDDPE VNWP P11LL_CKT W=0.425U
+  L=0.04U
X_M_ydec._wmux_1.MXP1 YW1 _YDEC._WMUX_1.INYP VDDPE VNWP P11LL_CKT W=7.94U
+  L=0.04U
X_M_ydec._wmux_1.MXP2 _YDEC._WMUX_1.INYP _YDEC.CLK_WR VDDPE VNWP P11LL_CKT
+  W=0.95U L=0.04U
.ENDS sram464x144CKM2
****
.SUBCKT sram464x144CNTRL ACTP BLPRECH_L BLPRECH_R CA0 CA1 CA2 CEN CLK DBL
+  DUM_SEL_D_L DUM_SEL_D_R DUM_SEL_TD_L DUM_SEL_TD_R DWL EMAW[0] EMAW[1]
+  EMA[0] EMA[1] EMA[2] GTP GWEN LA0 LA1 LA2 LA_P2[0] LA_P2[1] LA_P2[2] LOG0
+  LOG0_DWL LOG1 NACTC NACT_CC NGWE NRETNVT NSAE NWCLK NYR0 NYR1 RA0 RA1 RA2
+  RA3 RA4 RA5 RA_P2[0] RA_P2[1] RA_P2[2] RA_P2[3] RA_P2[4] RET RET1N
+  SAE_DUMMY SAPRECH VDDCE VDDC_LEFT VDDC_RIGHT VDDP VDDPE VPW YW0 YW1
** sram464x144CNTRL: 491 flat devices **
XCK ACTP BLPRECH_L BLPRECH_R CA0 CA1 CA2 CEN CLK DBL DUM_SEL_D_L DUM_SEL_D_R
+  DUM_SEL_TD_L DUM_SEL_TD_R DWL EMAW[0] EMAW[1] EMA[0] EMA[1] EMA[2] GTP GWEN
+  LA_P2[2] LA0 LA1 LA2 LA_P2[0] LA_P2[1] LA_P2[2] LOG0 LOG0_DWL LOG1 NACTC
+  NACT_CC NGWE NRETNVT NSAE NWCLK NYR0 NYR1 RA0 RA1 RA2 RA3 RA4 RA5 RA_P2[0]
+  RA_P2[1] RA_P2[2] RA_P2[3] RA_P2[4] LOG0 LOG0 RET RET1N SAE_DUMMY SAPRECH
+  VDDCE VDDCE VDDC_LEFT VDDCE VDDC_RIGHT VDDP VDDPE VDDPE VDDCE VDDPE VPW VPW
+  VPW YW0 YW1 sram464x144CKM2
.ENDS sram464x144CNTRL
****
.SUBCKT sram464x144IOCDM_R BL0_0 BL0_1 BL0_2 BL0_3 BL0_4 BL0_5 BL0_6 BL0_7
+  BL0_8 BL0_9 BL0_10 BL0_11 BL0_12 BL0_13 BL0_14 BL0_15 BL0_16 BL0_17 BL0_18
+  BL0_19 BL0_20 BL0_21 BL0_22 BL0_23 BL0_24 BL0_25 BL0_26 BL0_27 BL0_28
+  BL0_29 BL0_30 BL0_31 BL0_32 BL0_33 BL0_34 BL0_35 BL1_0 BL1_1 BL1_2 BL1_3
+  BL1_4 BL1_5 BL1_6 BL1_7 BL1_8 BL1_9 BL1_10 BL1_11 BL1_12 BL1_13 BL1_14
+  BL1_15 BL1_16 BL1_17 BL1_18 BL1_19 BL1_20 BL1_21 BL1_22 BL1_23 BL1_24
+  BL1_25 BL1_26 BL1_27 BL1_28 BL1_29 BL1_30 BL1_31 BL1_32 BL1_33 BL1_34
+  BL1_35 BL2_0 BL2_1 BL2_2 BL2_3 BL2_4 BL2_5 BL2_6 BL2_7 BL2_8 BL2_9 BL2_10
+  BL2_11 BL2_12 BL2_13 BL2_14 BL2_15 BL2_16 BL2_17 BL2_18 BL2_19 BL2_20
+  BL2_21 BL2_22 BL2_23 BL2_24 BL2_25 BL2_26 BL2_27 BL2_28 BL2_29 BL2_30
+  BL2_31 BL2_32 BL2_33 BL2_34 BL2_35 BL3_0 BL3_1 BL3_2 BL3_3 BL3_4 BL3_5
+  BL3_6 BL3_7 BL3_8 BL3_9 BL3_10 BL3_11 BL3_12 BL3_13 BL3_14 BL3_15 BL3_16
+  BL3_17 BL3_18 BL3_19 BL3_20 BL3_21 BL3_22 BL3_23 BL3_24 BL3_25 BL3_26
+  BL3_27 BL3_28 BL3_29 BL3_30 BL3_31 BL3_32 BL3_33 BL3_34 BL3_35 BLPRECH D0_0
+  D0_1 D0_2 D0_3 D0_4 D0_5 D0_6 D0_7 D0_8 D0_9 D0_10 D0_11 D0_12 D0_13 D0_14
+  D0_15 D0_16 D0_17 D0_18 D0_19 D0_20 D0_21 D0_22 D0_23 D0_24 D0_25 D0_26
+  D0_27 D0_28 D0_29 D0_30 D0_31 D0_32 D0_33 D0_34 D0_35 D1_0 D1_1 D1_2 D1_3
+  D1_4 D1_5 D1_6 D1_7 D1_8 D1_9 D1_10 D1_11 D1_12 D1_13 D1_14 D1_15 D1_16
+  D1_17 D1_18 D1_19 D1_20 D1_21 D1_22 D1_23 D1_24 D1_25 D1_26 D1_27 D1_28
+  D1_29 D1_30 D1_31 D1_32 D1_33 D1_34 D1_35 DUMMY[0]_0 DUMMY[0]_1 DUMMY[0]_2
+  DUMMY[0]_3 DUMMY[0]_4 DUMMY[0]_5 DUMMY[0]_6 DUMMY[0]_7 DUMMY[0]_8
+  DUMMY[0]_9 DUMMY[0]_10 DUMMY[0]_11 DUMMY[0]_12 DUMMY[0]_13 DUMMY[0]_14
+  DUMMY[0]_15 DUMMY[0]_16 DUMMY[0]_17 DUMMY[0]_18 DUMMY[0]_19 DUMMY[0]_20
+  DUMMY[0]_21 DUMMY[0]_22 DUMMY[0]_23 DUMMY[0]_24 DUMMY[0]_25 DUMMY[0]_26
+  DUMMY[0]_27 DUMMY[0]_28 DUMMY[0]_29 DUMMY[0]_30 DUMMY[0]_31 DUMMY[0]_32
+  DUMMY[0]_33 DUMMY[0]_34 DUMMY[0]_35 DUMMY[1]_0 DUMMY[1]_1 DUMMY[1]_2
+  DUMMY[1]_3 DUMMY[1]_4 DUMMY[1]_5 DUMMY[1]_6 DUMMY[1]_7 DUMMY[1]_8
+  DUMMY[1]_9 DUMMY[1]_10 DUMMY[1]_11 DUMMY[1]_12 DUMMY[1]_13 DUMMY[1]_14
+  DUMMY[1]_15 DUMMY[1]_16 DUMMY[1]_17 DUMMY[1]_18 DUMMY[1]_19 DUMMY[1]_20
+  DUMMY[1]_21 DUMMY[1]_22 DUMMY[1]_23 DUMMY[1]_24 DUMMY[1]_25 DUMMY[1]_26
+  DUMMY[1]_27 DUMMY[1]_28 DUMMY[1]_29 DUMMY[1]_30 DUMMY[1]_31 DUMMY[1]_32
+  DUMMY[1]_33 DUMMY[1]_34 DUMMY[1]_35 DUMMY[2]_0 DUMMY[2]_1 DUMMY[2]_2
+  DUMMY[2]_3 DUMMY[2]_4 DUMMY[2]_5 DUMMY[2]_6 DUMMY[2]_7 DUMMY[2]_8
+  DUMMY[2]_9 DUMMY[2]_10 DUMMY[2]_11 DUMMY[2]_12 DUMMY[2]_13 DUMMY[2]_14
+  DUMMY[2]_15 DUMMY[2]_16 DUMMY[2]_17 DUMMY[2]_18 DUMMY[2]_19 DUMMY[2]_20
+  DUMMY[2]_21 DUMMY[2]_22 DUMMY[2]_23 DUMMY[2]_24 DUMMY[2]_25 DUMMY[2]_26
+  DUMMY[2]_27 DUMMY[2]_28 DUMMY[2]_29 DUMMY[2]_30 DUMMY[2]_31 DUMMY[2]_32
+  DUMMY[2]_33 DUMMY[2]_34 DUMMY[2]_35 DUMMY[3]_0 DUMMY[3]_1 DUMMY[3]_2
+  DUMMY[3]_3 DUMMY[3]_4 DUMMY[3]_5 DUMMY[3]_6 DUMMY[3]_7 DUMMY[3]_8
+  DUMMY[3]_9 DUMMY[3]_10 DUMMY[3]_11 DUMMY[3]_12 DUMMY[3]_13 DUMMY[3]_14
+  DUMMY[3]_15 DUMMY[3]_16 DUMMY[3]_17 DUMMY[3]_18 DUMMY[3]_19 DUMMY[3]_20
+  DUMMY[3]_21 DUMMY[3]_22 DUMMY[3]_23 DUMMY[3]_24 DUMMY[3]_25 DUMMY[3]_26
+  DUMMY[3]_27 DUMMY[3]_28 DUMMY[3]_29 DUMMY[3]_30 DUMMY[3]_31 DUMMY[3]_32
+  DUMMY[3]_33 DUMMY[3]_34 DUMMY[3]_35 DUMMY[4]_0 DUMMY[4]_1 DUMMY[4]_2
+  DUMMY[4]_3 DUMMY[4]_4 DUMMY[4]_5 DUMMY[4]_6 DUMMY[4]_7 DUMMY[4]_8
+  DUMMY[4]_9 DUMMY[4]_10 DUMMY[4]_11 DUMMY[4]_12 DUMMY[4]_13 DUMMY[4]_14
+  DUMMY[4]_15 DUMMY[4]_16 DUMMY[4]_17 DUMMY[4]_18 DUMMY[4]_19 DUMMY[4]_20
+  DUMMY[4]_21 DUMMY[4]_22 DUMMY[4]_23 DUMMY[4]_24 DUMMY[4]_25 DUMMY[4]_26
+  DUMMY[4]_27 DUMMY[4]_28 DUMMY[4]_29 DUMMY[4]_30 DUMMY[4]_31 DUMMY[4]_32
+  DUMMY[4]_33 DUMMY[4]_34 DUMMY[4]_35 DUMMY[5]_0 DUMMY[5]_1 DUMMY[5]_2
+  DUMMY[5]_3 DUMMY[5]_4 DUMMY[5]_5 DUMMY[5]_6 DUMMY[5]_7 DUMMY[5]_8
+  DUMMY[5]_9 DUMMY[5]_10 DUMMY[5]_11 DUMMY[5]_12 DUMMY[5]_13 DUMMY[5]_14
+  DUMMY[5]_15 DUMMY[5]_16 DUMMY[5]_17 DUMMY[5]_18 DUMMY[5]_19 DUMMY[5]_20
+  DUMMY[5]_21 DUMMY[5]_22 DUMMY[5]_23 DUMMY[5]_24 DUMMY[5]_25 DUMMY[5]_26
+  DUMMY[5]_27 DUMMY[5]_28 DUMMY[5]_29 DUMMY[5]_30 DUMMY[5]_31 DUMMY[5]_32
+  DUMMY[5]_33 DUMMY[5]_34 DUMMY[5]_35 DUMMY[6]_0 DUMMY[6]_1 DUMMY[6]_2
+  DUMMY[6]_3 DUMMY[6]_4 DUMMY[6]_5 DUMMY[6]_6 DUMMY[6]_7 DUMMY[6]_8
+  DUMMY[6]_9 DUMMY[6]_10 DUMMY[6]_11 DUMMY[6]_12 DUMMY[6]_13 DUMMY[6]_14
+  DUMMY[6]_15 DUMMY[6]_16 DUMMY[6]_17 DUMMY[6]_18 DUMMY[6]_19 DUMMY[6]_20
+  DUMMY[6]_21 DUMMY[6]_22 DUMMY[6]_23 DUMMY[6]_24 DUMMY[6]_25 DUMMY[6]_26
+  DUMMY[6]_27 DUMMY[6]_28 DUMMY[6]_29 DUMMY[6]_30 DUMMY[6]_31 DUMMY[6]_32
+  DUMMY[6]_33 DUMMY[6]_34 DUMMY[6]_35 DUMMY[7]_0 DUMMY[7]_1 DUMMY[7]_2
+  DUMMY[7]_3 DUMMY[7]_4 DUMMY[7]_5 DUMMY[7]_6 DUMMY[7]_7 DUMMY[7]_8
+  DUMMY[7]_9 DUMMY[7]_10 DUMMY[7]_11 DUMMY[7]_12 DUMMY[7]_13 DUMMY[7]_14
+  DUMMY[7]_15 DUMMY[7]_16 DUMMY[7]_17 DUMMY[7]_18 DUMMY[7]_19 DUMMY[7]_20
+  DUMMY[7]_21 DUMMY[7]_22 DUMMY[7]_23 DUMMY[7]_24 DUMMY[7]_25 DUMMY[7]_26
+  DUMMY[7]_27 DUMMY[7]_28 DUMMY[7]_29 DUMMY[7]_30 DUMMY[7]_31 DUMMY[7]_32
+  DUMMY[7]_33 DUMMY[7]_34 DUMMY[7]_35 DWL LOG0 NACT_CC NBL0_0 NBL0_1 NBL0_2
+  NBL0_3 NBL0_4 NBL0_5 NBL0_6 NBL0_7 NBL0_8 NBL0_9 NBL0_10 NBL0_11 NBL0_12
+  NBL0_13 NBL0_14 NBL0_15 NBL0_16 NBL0_17 NBL0_18 NBL0_19 NBL0_20 NBL0_21
+  NBL0_22 NBL0_23 NBL0_24 NBL0_25 NBL0_26 NBL0_27 NBL0_28 NBL0_29 NBL0_30
+  NBL0_31 NBL0_32 NBL0_33 NBL0_34 NBL0_35 NBL1_0 NBL1_1 NBL1_2 NBL1_3 NBL1_4
+  NBL1_5 NBL1_6 NBL1_7 NBL1_8 NBL1_9 NBL1_10 NBL1_11 NBL1_12 NBL1_13 NBL1_14
+  NBL1_15 NBL1_16 NBL1_17 NBL1_18 NBL1_19 NBL1_20 NBL1_21 NBL1_22 NBL1_23
+  NBL1_24 NBL1_25 NBL1_26 NBL1_27 NBL1_28 NBL1_29 NBL1_30 NBL1_31 NBL1_32
+  NBL1_33 NBL1_34 NBL1_35 NBL2_0 NBL2_1 NBL2_2 NBL2_3 NBL2_4 NBL2_5 NBL2_6
+  NBL2_7 NBL2_8 NBL2_9 NBL2_10 NBL2_11 NBL2_12 NBL2_13 NBL2_14 NBL2_15
+  NBL2_16 NBL2_17 NBL2_18 NBL2_19 NBL2_20 NBL2_21 NBL2_22 NBL2_23 NBL2_24
+  NBL2_25 NBL2_26 NBL2_27 NBL2_28 NBL2_29 NBL2_30 NBL2_31 NBL2_32 NBL2_33
+  NBL2_34 NBL2_35 NBL3_0 NBL3_1 NBL3_2 NBL3_3 NBL3_4 NBL3_5 NBL3_6 NBL3_7
+  NBL3_8 NBL3_9 NBL3_10 NBL3_11 NBL3_12 NBL3_13 NBL3_14 NBL3_15 NBL3_16
+  NBL3_17 NBL3_18 NBL3_19 NBL3_20 NBL3_21 NBL3_22 NBL3_23 NBL3_24 NBL3_25
+  NBL3_26 NBL3_27 NBL3_28 NBL3_29 NBL3_30 NBL3_31 NBL3_32 NBL3_33 NBL3_34
+  NBL3_35 NSAE NWCLK NYR0 NYR1 SAO0_0 SAO0_1 SAO0_2 SAO0_3 SAO0_4 SAO0_5
+  SAO0_6 SAO0_7 SAO0_8 SAO0_9 SAO0_10 SAO0_11 SAO0_12 SAO0_13 SAO0_14 SAO0_15
+  SAO0_16 SAO0_17 SAO0_18 SAO0_19 SAO0_20 SAO0_21 SAO0_22 SAO0_23 SAO0_24
+  SAO0_25 SAO0_26 SAO0_27 SAO0_28 SAO0_29 SAO0_30 SAO0_31 SAO0_32 SAO0_33
+  SAO0_34 SAO0_35 SAO1_0 SAO1_1 SAO1_2 SAO1_3 SAO1_4 SAO1_5 SAO1_6 SAO1_7
+  SAO1_8 SAO1_9 SAO1_10 SAO1_11 SAO1_12 SAO1_13 SAO1_14 SAO1_15 SAO1_16
+  SAO1_17 SAO1_18 SAO1_19 SAO1_20 SAO1_21 SAO1_22 SAO1_23 SAO1_24 SAO1_25
+  SAO1_26 SAO1_27 SAO1_28 SAO1_29 SAO1_30 SAO1_31 SAO1_32 SAO1_33 SAO1_34
+  SAO1_35 SAPRECH VDDCE VDDC_0 VDDC_1 VDDC_2 VDDC_3 VDDC_4 VDDC_5 VDDC_6
+  VDDC_7 VDDC_8 VDDC_9 VDDC_10 VDDC_11 VDDC_12 VDDC_13 VDDC_14 VDDC_15
+  VDDC_16 VDDC_17 VDDC_18 VDDC_19 VDDC_20 VDDC_21 VDDC_22 VDDC_23 VDDC_24
+  VDDC_25 VDDC_26 VDDC_27 VDDC_28 VDDC_29 VDDC_30 VDDC_31 VDDC_32 VDDC_33
+  VDDC_34 VDDC_35 VDDPE VNWC_0 VNWC_1 VNWC_2 VNWC_3 VNWC_4 VNWC_5 VNWC_6
+  VNWC_7 VNWC_8 VNWC_9 VNWC_10 VNWC_11 VNWC_12 VNWC_13 VNWC_14 VNWC_15
+  VNWC_16 VNWC_17 VNWC_18 VNWC_19 VNWC_20 VNWC_21 VNWC_22 VNWC_23 VNWC_24
+  VNWC_25 VNWC_26 VNWC_27 VNWC_28 VNWC_29 VNWC_30 VNWC_31 VNWC_32 VNWC_33
+  VNWC_34 VNWC_35 VPW YW0 YW1
** sram464x144IOCDM_R: 4788 flat devices **
XR_IO_I1 BL0_1 BL1_1 BL2_1 BL3_1 BLPRECH D0_1 D1_1 DUMMY[0]_1 DUMMY[1]_1
+  DUMMY[2]_1 DUMMY[3]_1 DUMMY[4]_1 DUMMY[5]_1 DUMMY[6]_1 DUMMY[7]_1 DWL LOG0
+  NACT_CC NBL0_1 NBL1_1 NBL2_1 NBL3_1 NSAE NWCLK NYR0 NYR1 SAO0_1 SAO1_1
+  SAPRECH VDDC_1 VDDCE VDDPE VNWC_1 VDDPE VPW VPW VPW YW0 YW1
+  sram464x144COLM2X2
XR_IO_I10 BL0_10 BL1_10 BL2_10 BL3_10 BLPRECH D0_10 D1_10 DUMMY[0]_10
+  DUMMY[1]_10 DUMMY[2]_10 DUMMY[3]_10 DUMMY[4]_10 DUMMY[5]_10 DUMMY[6]_10
+  DUMMY[7]_10 DWL LOG0 NACT_CC NBL0_10 NBL1_10 NBL2_10 NBL3_10 NSAE NWCLK
+  NYR0 NYR1 SAO0_10 SAO1_10 SAPRECH VDDC_10 VDDCE VDDPE VNWC_10 VDDPE VPW VPW
+  VPW YW0 YW1 sram464x144COLM2X2
XR_IO_I11 BL0_11 BL1_11 BL2_11 BL3_11 BLPRECH D0_11 D1_11 DUMMY[0]_11
+  DUMMY[1]_11 DUMMY[2]_11 DUMMY[3]_11 DUMMY[4]_11 DUMMY[5]_11 DUMMY[6]_11
+  DUMMY[7]_11 DWL LOG0 NACT_CC NBL0_11 NBL1_11 NBL2_11 NBL3_11 NSAE NWCLK
+  NYR0 NYR1 SAO0_11 SAO1_11 SAPRECH VDDC_11 VDDCE VDDPE VNWC_11 VDDPE VPW VPW
+  VPW YW0 YW1 sram464x144COLM2X2
XR_IO_I12 BL0_12 BL1_12 BL2_12 BL3_12 BLPRECH D0_12 D1_12 DUMMY[0]_12
+  DUMMY[1]_12 DUMMY[2]_12 DUMMY[3]_12 DUMMY[4]_12 DUMMY[5]_12 DUMMY[6]_12
+  DUMMY[7]_12 DWL LOG0 NACT_CC NBL0_12 NBL1_12 NBL2_12 NBL3_12 NSAE NWCLK
+  NYR0 NYR1 SAO0_12 SAO1_12 SAPRECH VDDC_12 VDDCE VDDPE VNWC_12 VDDPE VPW VPW
+  VPW YW0 YW1 sram464x144COLM2X2
XR_IO_I13 BL0_13 BL1_13 BL2_13 BL3_13 BLPRECH D0_13 D1_13 DUMMY[0]_13
+  DUMMY[1]_13 DUMMY[2]_13 DUMMY[3]_13 DUMMY[4]_13 DUMMY[5]_13 DUMMY[6]_13
+  DUMMY[7]_13 DWL LOG0 NACT_CC NBL0_13 NBL1_13 NBL2_13 NBL3_13 NSAE NWCLK
+  NYR0 NYR1 SAO0_13 SAO1_13 SAPRECH VDDC_13 VDDCE VDDPE VNWC_13 VDDPE VPW VPW
+  VPW YW0 YW1 sram464x144COLM2X2
XR_IO_I14 BL0_14 BL1_14 BL2_14 BL3_14 BLPRECH D0_14 D1_14 DUMMY[0]_14
+  DUMMY[1]_14 DUMMY[2]_14 DUMMY[3]_14 DUMMY[4]_14 DUMMY[5]_14 DUMMY[6]_14
+  DUMMY[7]_14 DWL LOG0 NACT_CC NBL0_14 NBL1_14 NBL2_14 NBL3_14 NSAE NWCLK
+  NYR0 NYR1 SAO0_14 SAO1_14 SAPRECH VDDC_14 VDDCE VDDPE VNWC_14 VDDPE VPW VPW
+  VPW YW0 YW1 sram464x144COLM2X2
XR_IO_I15 BL0_15 BL1_15 BL2_15 BL3_15 BLPRECH D0_15 D1_15 DUMMY[0]_15
+  DUMMY[1]_15 DUMMY[2]_15 DUMMY[3]_15 DUMMY[4]_15 DUMMY[5]_15 DUMMY[6]_15
+  DUMMY[7]_15 DWL LOG0 NACT_CC NBL0_15 NBL1_15 NBL2_15 NBL3_15 NSAE NWCLK
+  NYR0 NYR1 SAO0_15 SAO1_15 SAPRECH VDDC_15 VDDCE VDDPE VNWC_15 VDDPE VPW VPW
+  VPW YW0 YW1 sram464x144COLM2X2
XR_IO_I16 BL0_16 BL1_16 BL2_16 BL3_16 BLPRECH D0_16 D1_16 DUMMY[0]_16
+  DUMMY[1]_16 DUMMY[2]_16 DUMMY[3]_16 DUMMY[4]_16 DUMMY[5]_16 DUMMY[6]_16
+  DUMMY[7]_16 DWL LOG0 NACT_CC NBL0_16 NBL1_16 NBL2_16 NBL3_16 NSAE NWCLK
+  NYR0 NYR1 SAO0_16 SAO1_16 SAPRECH VDDC_16 VDDCE VDDPE VNWC_16 VDDPE VPW VPW
+  VPW YW0 YW1 sram464x144COLM2X2
XR_IO_I17 BL0_17 BL1_17 BL2_17 BL3_17 BLPRECH D0_17 D1_17 DUMMY[0]_17
+  DUMMY[1]_17 DUMMY[2]_17 DUMMY[3]_17 DUMMY[4]_17 DUMMY[5]_17 DUMMY[6]_17
+  DUMMY[7]_17 DWL LOG0 NACT_CC NBL0_17 NBL1_17 NBL2_17 NBL3_17 NSAE NWCLK
+  NYR0 NYR1 SAO0_17 SAO1_17 SAPRECH VDDC_17 VDDCE VDDPE VNWC_17 VDDPE VPW VPW
+  VPW YW0 YW1 sram464x144COLM2X2
XR_IO_I18 BL0_18 BL1_18 BL2_18 BL3_18 BLPRECH D0_18 D1_18 DUMMY[0]_18
+  DUMMY[1]_18 DUMMY[2]_18 DUMMY[3]_18 DUMMY[4]_18 DUMMY[5]_18 DUMMY[6]_18
+  DUMMY[7]_18 DWL LOG0 NACT_CC NBL0_18 NBL1_18 NBL2_18 NBL3_18 NSAE NWCLK
+  NYR0 NYR1 SAO0_18 SAO1_18 SAPRECH VDDC_18 VDDCE VDDPE VNWC_18 VDDPE VPW VPW
+  VPW YW0 YW1 sram464x144COLM2X2
XR_IO_I19 BL0_19 BL1_19 BL2_19 BL3_19 BLPRECH D0_19 D1_19 DUMMY[0]_19
+  DUMMY[1]_19 DUMMY[2]_19 DUMMY[3]_19 DUMMY[4]_19 DUMMY[5]_19 DUMMY[6]_19
+  DUMMY[7]_19 DWL LOG0 NACT_CC NBL0_19 NBL1_19 NBL2_19 NBL3_19 NSAE NWCLK
+  NYR0 NYR1 SAO0_19 SAO1_19 SAPRECH VDDC_19 VDDCE VDDPE VNWC_19 VDDPE VPW VPW
+  VPW YW0 YW1 sram464x144COLM2X2
XR_IO_I2 BL0_2 BL1_2 BL2_2 BL3_2 BLPRECH D0_2 D1_2 DUMMY[0]_2 DUMMY[1]_2
+  DUMMY[2]_2 DUMMY[3]_2 DUMMY[4]_2 DUMMY[5]_2 DUMMY[6]_2 DUMMY[7]_2 DWL LOG0
+  NACT_CC NBL0_2 NBL1_2 NBL2_2 NBL3_2 NSAE NWCLK NYR0 NYR1 SAO0_2 SAO1_2
+  SAPRECH VDDC_2 VDDCE VDDPE VNWC_2 VDDPE VPW VPW VPW YW0 YW1
+  sram464x144COLM2X2
XR_IO_I20 BL0_20 BL1_20 BL2_20 BL3_20 BLPRECH D0_20 D1_20 DUMMY[0]_20
+  DUMMY[1]_20 DUMMY[2]_20 DUMMY[3]_20 DUMMY[4]_20 DUMMY[5]_20 DUMMY[6]_20
+  DUMMY[7]_20 DWL LOG0 NACT_CC NBL0_20 NBL1_20 NBL2_20 NBL3_20 NSAE NWCLK
+  NYR0 NYR1 SAO0_20 SAO1_20 SAPRECH VDDC_20 VDDCE VDDPE VNWC_20 VDDPE VPW VPW
+  VPW YW0 YW1 sram464x144COLM2X2
XR_IO_I21 BL0_21 BL1_21 BL2_21 BL3_21 BLPRECH D0_21 D1_21 DUMMY[0]_21
+  DUMMY[1]_21 DUMMY[2]_21 DUMMY[3]_21 DUMMY[4]_21 DUMMY[5]_21 DUMMY[6]_21
+  DUMMY[7]_21 DWL LOG0 NACT_CC NBL0_21 NBL1_21 NBL2_21 NBL3_21 NSAE NWCLK
+  NYR0 NYR1 SAO0_21 SAO1_21 SAPRECH VDDC_21 VDDCE VDDPE VNWC_21 VDDPE VPW VPW
+  VPW YW0 YW1 sram464x144COLM2X2
XR_IO_I22 BL0_22 BL1_22 BL2_22 BL3_22 BLPRECH D0_22 D1_22 DUMMY[0]_22
+  DUMMY[1]_22 DUMMY[2]_22 DUMMY[3]_22 DUMMY[4]_22 DUMMY[5]_22 DUMMY[6]_22
+  DUMMY[7]_22 DWL LOG0 NACT_CC NBL0_22 NBL1_22 NBL2_22 NBL3_22 NSAE NWCLK
+  NYR0 NYR1 SAO0_22 SAO1_22 SAPRECH VDDC_22 VDDCE VDDPE VNWC_22 VDDPE VPW VPW
+  VPW YW0 YW1 sram464x144COLM2X2
XR_IO_I23 BL0_23 BL1_23 BL2_23 BL3_23 BLPRECH D0_23 D1_23 DUMMY[0]_23
+  DUMMY[1]_23 DUMMY[2]_23 DUMMY[3]_23 DUMMY[4]_23 DUMMY[5]_23 DUMMY[6]_23
+  DUMMY[7]_23 DWL LOG0 NACT_CC NBL0_23 NBL1_23 NBL2_23 NBL3_23 NSAE NWCLK
+  NYR0 NYR1 SAO0_23 SAO1_23 SAPRECH VDDC_23 VDDCE VDDPE VNWC_23 VDDPE VPW VPW
+  VPW YW0 YW1 sram464x144COLM2X2
XR_IO_I24 BL0_24 BL1_24 BL2_24 BL3_24 BLPRECH D0_24 D1_24 DUMMY[0]_24
+  DUMMY[1]_24 DUMMY[2]_24 DUMMY[3]_24 DUMMY[4]_24 DUMMY[5]_24 DUMMY[6]_24
+  DUMMY[7]_24 DWL LOG0 NACT_CC NBL0_24 NBL1_24 NBL2_24 NBL3_24 NSAE NWCLK
+  NYR0 NYR1 SAO0_24 SAO1_24 SAPRECH VDDC_24 VDDCE VDDPE VNWC_24 VDDPE VPW VPW
+  VPW YW0 YW1 sram464x144COLM2X2
XR_IO_I25 BL0_25 BL1_25 BL2_25 BL3_25 BLPRECH D0_25 D1_25 DUMMY[0]_25
+  DUMMY[1]_25 DUMMY[2]_25 DUMMY[3]_25 DUMMY[4]_25 DUMMY[5]_25 DUMMY[6]_25
+  DUMMY[7]_25 DWL LOG0 NACT_CC NBL0_25 NBL1_25 NBL2_25 NBL3_25 NSAE NWCLK
+  NYR0 NYR1 SAO0_25 SAO1_25 SAPRECH VDDC_25 VDDCE VDDPE VNWC_25 VDDPE VPW VPW
+  VPW YW0 YW1 sram464x144COLM2X2
XR_IO_I26 BL0_26 BL1_26 BL2_26 BL3_26 BLPRECH D0_26 D1_26 DUMMY[0]_26
+  DUMMY[1]_26 DUMMY[2]_26 DUMMY[3]_26 DUMMY[4]_26 DUMMY[5]_26 DUMMY[6]_26
+  DUMMY[7]_26 DWL LOG0 NACT_CC NBL0_26 NBL1_26 NBL2_26 NBL3_26 NSAE NWCLK
+  NYR0 NYR1 SAO0_26 SAO1_26 SAPRECH VDDC_26 VDDCE VDDPE VNWC_26 VDDPE VPW VPW
+  VPW YW0 YW1 sram464x144COLM2X2
XR_IO_I27 BL0_27 BL1_27 BL2_27 BL3_27 BLPRECH D0_27 D1_27 DUMMY[0]_27
+  DUMMY[1]_27 DUMMY[2]_27 DUMMY[3]_27 DUMMY[4]_27 DUMMY[5]_27 DUMMY[6]_27
+  DUMMY[7]_27 DWL LOG0 NACT_CC NBL0_27 NBL1_27 NBL2_27 NBL3_27 NSAE NWCLK
+  NYR0 NYR1 SAO0_27 SAO1_27 SAPRECH VDDC_27 VDDCE VDDPE VNWC_27 VDDPE VPW VPW
+  VPW YW0 YW1 sram464x144COLM2X2
XR_IO_I28 BL0_28 BL1_28 BL2_28 BL3_28 BLPRECH D0_28 D1_28 DUMMY[0]_28
+  DUMMY[1]_28 DUMMY[2]_28 DUMMY[3]_28 DUMMY[4]_28 DUMMY[5]_28 DUMMY[6]_28
+  DUMMY[7]_28 DWL LOG0 NACT_CC NBL0_28 NBL1_28 NBL2_28 NBL3_28 NSAE NWCLK
+  NYR0 NYR1 SAO0_28 SAO1_28 SAPRECH VDDC_28 VDDCE VDDPE VNWC_28 VDDPE VPW VPW
+  VPW YW0 YW1 sram464x144COLM2X2
XR_IO_I29 BL0_29 BL1_29 BL2_29 BL3_29 BLPRECH D0_29 D1_29 DUMMY[0]_29
+  DUMMY[1]_29 DUMMY[2]_29 DUMMY[3]_29 DUMMY[4]_29 DUMMY[5]_29 DUMMY[6]_29
+  DUMMY[7]_29 DWL LOG0 NACT_CC NBL0_29 NBL1_29 NBL2_29 NBL3_29 NSAE NWCLK
+  NYR0 NYR1 SAO0_29 SAO1_29 SAPRECH VDDC_29 VDDCE VDDPE VNWC_29 VDDPE VPW VPW
+  VPW YW0 YW1 sram464x144COLM2X2
XR_IO_I3 BL0_3 BL1_3 BL2_3 BL3_3 BLPRECH D0_3 D1_3 DUMMY[0]_3 DUMMY[1]_3
+  DUMMY[2]_3 DUMMY[3]_3 DUMMY[4]_3 DUMMY[5]_3 DUMMY[6]_3 DUMMY[7]_3 DWL LOG0
+  NACT_CC NBL0_3 NBL1_3 NBL2_3 NBL3_3 NSAE NWCLK NYR0 NYR1 SAO0_3 SAO1_3
+  SAPRECH VDDC_3 VDDCE VDDPE VNWC_3 VDDPE VPW VPW VPW YW0 YW1
+  sram464x144COLM2X2
XR_IO_I30 BL0_30 BL1_30 BL2_30 BL3_30 BLPRECH D0_30 D1_30 DUMMY[0]_30
+  DUMMY[1]_30 DUMMY[2]_30 DUMMY[3]_30 DUMMY[4]_30 DUMMY[5]_30 DUMMY[6]_30
+  DUMMY[7]_30 DWL LOG0 NACT_CC NBL0_30 NBL1_30 NBL2_30 NBL3_30 NSAE NWCLK
+  NYR0 NYR1 SAO0_30 SAO1_30 SAPRECH VDDC_30 VDDCE VDDPE VNWC_30 VDDPE VPW VPW
+  VPW YW0 YW1 sram464x144COLM2X2
XR_IO_I31 BL0_31 BL1_31 BL2_31 BL3_31 BLPRECH D0_31 D1_31 DUMMY[0]_31
+  DUMMY[1]_31 DUMMY[2]_31 DUMMY[3]_31 DUMMY[4]_31 DUMMY[5]_31 DUMMY[6]_31
+  DUMMY[7]_31 DWL LOG0 NACT_CC NBL0_31 NBL1_31 NBL2_31 NBL3_31 NSAE NWCLK
+  NYR0 NYR1 SAO0_31 SAO1_31 SAPRECH VDDC_31 VDDCE VDDPE VNWC_31 VDDPE VPW VPW
+  VPW YW0 YW1 sram464x144COLM2X2
XR_IO_I32 BL0_32 BL1_32 BL2_32 BL3_32 BLPRECH D0_32 D1_32 DUMMY[0]_32
+  DUMMY[1]_32 DUMMY[2]_32 DUMMY[3]_32 DUMMY[4]_32 DUMMY[5]_32 DUMMY[6]_32
+  DUMMY[7]_32 DWL LOG0 NACT_CC NBL0_32 NBL1_32 NBL2_32 NBL3_32 NSAE NWCLK
+  NYR0 NYR1 SAO0_32 SAO1_32 SAPRECH VDDC_32 VDDCE VDDPE VNWC_32 VDDPE VPW VPW
+  VPW YW0 YW1 sram464x144COLM2X2
XR_IO_I33 BL0_33 BL1_33 BL2_33 BL3_33 BLPRECH D0_33 D1_33 DUMMY[0]_33
+  DUMMY[1]_33 DUMMY[2]_33 DUMMY[3]_33 DUMMY[4]_33 DUMMY[5]_33 DUMMY[6]_33
+  DUMMY[7]_33 DWL LOG0 NACT_CC NBL0_33 NBL1_33 NBL2_33 NBL3_33 NSAE NWCLK
+  NYR0 NYR1 SAO0_33 SAO1_33 SAPRECH VDDC_33 VDDCE VDDPE VNWC_33 VDDPE VPW VPW
+  VPW YW0 YW1 sram464x144COLM2X2
XR_IO_I34 BL0_34 BL1_34 BL2_34 BL3_34 BLPRECH D0_34 D1_34 DUMMY[0]_34
+  DUMMY[1]_34 DUMMY[2]_34 DUMMY[3]_34 DUMMY[4]_34 DUMMY[5]_34 DUMMY[6]_34
+  DUMMY[7]_34 DWL LOG0 NACT_CC NBL0_34 NBL1_34 NBL2_34 NBL3_34 NSAE NWCLK
+  NYR0 NYR1 SAO0_34 SAO1_34 SAPRECH VDDC_34 VDDCE VDDPE VNWC_34 VDDPE VPW VPW
+  VPW YW0 YW1 sram464x144COLM2X2
XR_IO_I4 BL0_4 BL1_4 BL2_4 BL3_4 BLPRECH D0_4 D1_4 DUMMY[0]_4 DUMMY[1]_4
+  DUMMY[2]_4 DUMMY[3]_4 DUMMY[4]_4 DUMMY[5]_4 DUMMY[6]_4 DUMMY[7]_4 DWL LOG0
+  NACT_CC NBL0_4 NBL1_4 NBL2_4 NBL3_4 NSAE NWCLK NYR0 NYR1 SAO0_4 SAO1_4
+  SAPRECH VDDC_4 VDDCE VDDPE VNWC_4 VDDPE VPW VPW VPW YW0 YW1
+  sram464x144COLM2X2
XR_IO_I5 BL0_5 BL1_5 BL2_5 BL3_5 BLPRECH D0_5 D1_5 DUMMY[0]_5 DUMMY[1]_5
+  DUMMY[2]_5 DUMMY[3]_5 DUMMY[4]_5 DUMMY[5]_5 DUMMY[6]_5 DUMMY[7]_5 DWL LOG0
+  NACT_CC NBL0_5 NBL1_5 NBL2_5 NBL3_5 NSAE NWCLK NYR0 NYR1 SAO0_5 SAO1_5
+  SAPRECH VDDC_5 VDDCE VDDPE VNWC_5 VDDPE VPW VPW VPW YW0 YW1
+  sram464x144COLM2X2
XR_IO_I6 BL0_6 BL1_6 BL2_6 BL3_6 BLPRECH D0_6 D1_6 DUMMY[0]_6 DUMMY[1]_6
+  DUMMY[2]_6 DUMMY[3]_6 DUMMY[4]_6 DUMMY[5]_6 DUMMY[6]_6 DUMMY[7]_6 DWL LOG0
+  NACT_CC NBL0_6 NBL1_6 NBL2_6 NBL3_6 NSAE NWCLK NYR0 NYR1 SAO0_6 SAO1_6
+  SAPRECH VDDC_6 VDDCE VDDPE VNWC_6 VDDPE VPW VPW VPW YW0 YW1
+  sram464x144COLM2X2
XR_IO_I7 BL0_7 BL1_7 BL2_7 BL3_7 BLPRECH D0_7 D1_7 DUMMY[0]_7 DUMMY[1]_7
+  DUMMY[2]_7 DUMMY[3]_7 DUMMY[4]_7 DUMMY[5]_7 DUMMY[6]_7 DUMMY[7]_7 DWL LOG0
+  NACT_CC NBL0_7 NBL1_7 NBL2_7 NBL3_7 NSAE NWCLK NYR0 NYR1 SAO0_7 SAO1_7
+  SAPRECH VDDC_7 VDDCE VDDPE VNWC_7 VDDPE VPW VPW VPW YW0 YW1
+  sram464x144COLM2X2
XR_IO_I8 BL0_8 BL1_8 BL2_8 BL3_8 BLPRECH D0_8 D1_8 DUMMY[0]_8 DUMMY[1]_8
+  DUMMY[2]_8 DUMMY[3]_8 DUMMY[4]_8 DUMMY[5]_8 DUMMY[6]_8 DUMMY[7]_8 DWL LOG0
+  NACT_CC NBL0_8 NBL1_8 NBL2_8 NBL3_8 NSAE NWCLK NYR0 NYR1 SAO0_8 SAO1_8
+  SAPRECH VDDC_8 VDDCE VDDPE VNWC_8 VDDPE VPW VPW VPW YW0 YW1
+  sram464x144COLM2X2
XR_IO_I9 BL0_9 BL1_9 BL2_9 BL3_9 BLPRECH D0_9 D1_9 DUMMY[0]_9 DUMMY[1]_9
+  DUMMY[2]_9 DUMMY[3]_9 DUMMY[4]_9 DUMMY[5]_9 DUMMY[6]_9 DUMMY[7]_9 DWL LOG0
+  NACT_CC NBL0_9 NBL1_9 NBL2_9 NBL3_9 NSAE NWCLK NYR0 NYR1 SAO0_9 SAO1_9
+  SAPRECH VDDC_9 VDDCE VDDPE VNWC_9 VDDPE VPW VPW VPW YW0 YW1
+  sram464x144COLM2X2
XR_IO_L BL0_0 BL1_0 BL2_0 BL3_0 BLPRECH D0_0 D1_0 DUMMY[0]_0 DUMMY[1]_0
+  DUMMY[2]_0 DUMMY[3]_0 DUMMY[4]_0 DUMMY[5]_0 DUMMY[6]_0 DUMMY[7]_0 DWL LOG0
+  NACT_CC NBL0_0 NBL1_0 NBL2_0 NBL3_0 NSAE NWCLK NYR0 NYR1 SAO0_0 SAO1_0
+  SAPRECH VDDC_0 VDDCE VDDPE VNWC_0 VDDPE VPW VPW VPW YW0 YW1
+  sram464x144COLM2X2
XR_IO_R BL0_35 BL1_35 BL2_35 BL3_35 BLPRECH D0_35 D1_35 DUMMY[0]_35
+  DUMMY[1]_35 DUMMY[2]_35 DUMMY[3]_35 DUMMY[4]_35 DUMMY[5]_35 DUMMY[6]_35
+  DUMMY[7]_35 DWL LOG0 NACT_CC NBL0_35 NBL1_35 NBL2_35 NBL3_35 NSAE NWCLK
+  NYR0 NYR1 SAO0_35 SAO1_35 SAPRECH VDDC_35 VDDCE VDDPE VNWC_35 VDDPE VPW VPW
+  VPW YW0 YW1 sram464x144COLM2X2
.ENDS sram464x144IOCDM_R
****
.SUBCKT sram464x144IO_RDM_R D0_0 D0_1 D0_2 D0_3 D0_4 D0_5 D0_6 D0_7 D0_8 D0_9
+  D0_10 D0_11 D0_12 D0_13 D0_14 D0_15 D0_16 D0_17 D0_18 D0_19 D0_20 D0_21
+  D0_22 D0_23 D0_24 D0_25 D0_26 D0_27 D0_28 D0_29 D0_30 D0_31 D0_32 D0_33
+  D0_34 D0_35 D1_0 D1_1 D1_2 D1_3 D1_4 D1_5 D1_6 D1_7 D1_8 D1_9 D1_10 D1_11
+  D1_12 D1_13 D1_14 D1_15 D1_16 D1_17 D1_18 D1_19 D1_20 D1_21 D1_22 D1_23
+  D1_24 D1_25 D1_26 D1_27 D1_28 D1_29 D1_30 D1_31 D1_32 D1_33 D1_34 D1_35
+  DUM_SEL_D_L DUM_SEL_D_R DUM_SEL_TD_L DUM_SEL_TD_R Q0_0 Q0_1 Q0_2 Q0_3 Q0_4
+  Q0_5 Q0_6 Q0_7 Q0_8 Q0_9 Q0_10 Q0_11 Q0_12 Q0_13 Q0_14 Q0_15 Q0_16 Q0_17
+  Q0_18 Q0_19 Q0_20 Q0_21 Q0_22 Q0_23 Q0_24 Q0_25 Q0_26 Q0_27 Q0_28 Q0_29
+  Q0_30 Q0_31 Q0_32 Q0_33 Q0_34 Q0_35 Q1_0 Q1_1 Q1_2 Q1_3 Q1_4 Q1_5 Q1_6 Q1_7
+  Q1_8 Q1_9 Q1_10 Q1_11 Q1_12 Q1_13 Q1_14 Q1_15 Q1_16 Q1_17 Q1_18 Q1_19 Q1_20
+  Q1_21 Q1_22 Q1_23 Q1_24 Q1_25 Q1_26 Q1_27 Q1_28 Q1_29 Q1_30 Q1_31 Q1_32
+  Q1_33 Q1_34 Q1_35 SAO0_0 SAO0_1 SAO0_2 SAO0_3 SAO0_4 SAO0_5 SAO0_6 SAO0_7
+  SAO0_8 SAO0_9 SAO0_10 SAO0_11 SAO0_12 SAO0_13 SAO0_14 SAO0_15 SAO0_16
+  SAO0_17 SAO0_18 SAO0_19 SAO0_20 SAO0_21 SAO0_22 SAO0_23 SAO0_24 SAO0_25
+  SAO0_26 SAO0_27 SAO0_28 SAO0_29 SAO0_30 SAO0_31 SAO0_32 SAO0_33 SAO0_34
+  SAO0_35 SAO1_0 SAO1_1 SAO1_2 SAO1_3 SAO1_4 SAO1_5 SAO1_6 SAO1_7 SAO1_8
+  SAO1_9 SAO1_10 SAO1_11 SAO1_12 SAO1_13 SAO1_14 SAO1_15 SAO1_16 SAO1_17
+  SAO1_18 SAO1_19 SAO1_20 SAO1_21 SAO1_22 SAO1_23 SAO1_24 SAO1_25 SAO1_26
+  SAO1_27 SAO1_28 SAO1_29 SAO1_30 SAO1_31 SAO1_32 SAO1_33 SAO1_34 SAO1_35
+  TD0_0 TD0_1 TD0_2 TD0_3 TD0_4 TD0_5 TD0_6 TD0_7 TD0_8 TD0_9 TD0_10 TD0_11
+  TD0_12 TD0_13 TD0_14 TD0_15 TD0_16 TD0_17 TD0_18 TD0_19 TD0_20 TD0_21
+  TD0_22 TD0_23 TD0_24 TD0_25 TD0_26 TD0_27 TD0_28 TD0_29 TD0_30 TD0_31
+  TD0_32 TD0_33 TD0_34 TD0_35 TD1_0 TD1_1 TD1_2 TD1_3 TD1_4 TD1_5 TD1_6 TD1_7
+  TD1_8 TD1_9 TD1_10 TD1_11 TD1_12 TD1_13 TD1_14 TD1_15 TD1_16 TD1_17 TD1_18
+  TD1_19 TD1_20 TD1_21 TD1_22 TD1_23 TD1_24 TD1_25 TD1_26 TD1_27 TD1_28
+  TD1_29 TD1_30 TD1_31 TD1_32 TD1_33 TD1_34 TD1_35 TWEN0_0 TWEN0_1 TWEN0_2
+  TWEN0_3 TWEN0_4 TWEN0_5 TWEN0_6 TWEN0_7 TWEN0_8 TWEN0_9 TWEN0_10 TWEN0_11
+  TWEN0_12 TWEN0_13 TWEN0_14 TWEN0_15 TWEN0_16 TWEN0_17 TWEN0_18 TWEN0_19
+  TWEN0_20 TWEN0_21 TWEN0_22 TWEN0_23 TWEN0_24 TWEN0_25 TWEN0_26 TWEN0_27
+  TWEN0_28 TWEN0_29 TWEN0_30 TWEN0_31 TWEN0_32 TWEN0_33 TWEN0_34 TWEN0_35
+  TWEN1_0 TWEN1_1 TWEN1_2 TWEN1_3 TWEN1_4 TWEN1_5 TWEN1_6 TWEN1_7 TWEN1_8
+  TWEN1_9 TWEN1_10 TWEN1_11 TWEN1_12 TWEN1_13 TWEN1_14 TWEN1_15 TWEN1_16
+  TWEN1_17 TWEN1_18 TWEN1_19 TWEN1_20 TWEN1_21 TWEN1_22 TWEN1_23 TWEN1_24
+  TWEN1_25 TWEN1_26 TWEN1_27 TWEN1_28 TWEN1_29 TWEN1_30 TWEN1_31 TWEN1_32
+  TWEN1_33 TWEN1_34 TWEN1_35 VDDCE_0 VDDCE_1 VDDCE_2 VDDCE_3 VDDCE_4 VDDCE_5
+  VDDCE_6 VDDCE_7 VDDCE_8 VDDCE_9 VDDCE_10 VDDCE_11 VDDCE_12 VDDCE_13
+  VDDCE_14 VDDCE_15 VDDCE_16 VDDCE_17 VDDCE_18 VDDCE_19 VDDCE_20 VDDCE_21
+  VDDCE_22 VDDCE_23 VDDCE_24 VDDCE_25 VDDCE_26 VDDCE_27 VDDCE_28 VDDCE_29
+  VDDCE_30 VDDCE_31 VDDCE_32 VDDCE_33 VDDCE_34 VDDCE_35 VDDPE_0 VDDPE_1
+  VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8 VDDPE_9 VDDPE_10
+  VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16 VDDPE_17 VDDPE_18
+  VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24 VDDPE_25 VDDPE_26
+  VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32 VDDPE_33 VDDPE_34
+  VDDPE_35 VNWP_0 VNWP_1 VNWP_2 VNWP_3 VNWP_4 VNWP_5 VNWP_6 VNWP_7 VNWP_8
+  VNWP_9 VNWP_10 VNWP_11 VNWP_12 VNWP_13 VNWP_14 VNWP_15 VNWP_16 VNWP_17
+  VNWP_18 VNWP_19 VNWP_20 VNWP_21 VNWP_22 VNWP_23 VNWP_24 VNWP_25 VNWP_26
+  VNWP_27 VNWP_28 VNWP_29 VNWP_30 VNWP_31 VNWP_32 VNWP_33 VNWP_34 VNWP_35
+  VPW_0 VPW_1 VPW_2 VPW_3 VPW_4 VPW_5 VPW_6 VPW_7 VPW_8 VPW_9 VPW_10 VPW_11
+  VPW_12 VPW_13 VPW_14 VPW_15 VPW_16 VPW_17 VPW_18 VPW_19 VPW_20 VPW_21
+  VPW_22 VPW_23 VPW_24 VPW_25 VPW_26 VPW_27 VPW_28 VPW_29 VPW_30 VPW_31
+  VPW_32 VPW_33 VPW_34 VPW_35 VSS_0 VSS_1 VSS_2 VSS_3 VSS_4 VSS_5 VSS_6 VSS_7
+  VSS_8 VSS_9 VSS_10 VSS_11 VSS_12 VSS_13 VSS_14 VSS_15 VSS_16 VSS_17 VSS_18
+  VSS_19 VSS_20 VSS_21 VSS_22 VSS_23 VSS_24 VSS_25 VSS_26 VSS_27 VSS_28
+  VSS_29 VSS_30 VSS_31 VSS_32 VSS_33 VSS_34 VSS_35 WEN0_0 WEN0_1 WEN0_2
+  WEN0_3 WEN0_4 WEN0_5 WEN0_6 WEN0_7 WEN0_8 WEN0_9 WEN0_10 WEN0_11 WEN0_12
+  WEN0_13 WEN0_14 WEN0_15 WEN0_16 WEN0_17 WEN0_18 WEN0_19 WEN0_20 WEN0_21
+  WEN0_22 WEN0_23 WEN0_24 WEN0_25 WEN0_26 WEN0_27 WEN0_28 WEN0_29 WEN0_30
+  WEN0_31 WEN0_32 WEN0_33 WEN0_34 WEN0_35 WEN1_0 WEN1_1 WEN1_2 WEN1_3 WEN1_4
+  WEN1_5 WEN1_6 WEN1_7 WEN1_8 WEN1_9 WEN1_10 WEN1_11 WEN1_12 WEN1_13 WEN1_14
+  WEN1_15 WEN1_16 WEN1_17 WEN1_18 WEN1_19 WEN1_20 WEN1_21 WEN1_22 WEN1_23
+  WEN1_24 WEN1_25 WEN1_26 WEN1_27 WEN1_28 WEN1_29 WEN1_30 WEN1_31 WEN1_32
+  WEN1_33 WEN1_34 WEN1_35 WENY0_0 WENY0_1 WENY0_2 WENY0_3 WENY0_4 WENY0_5
+  WENY0_6 WENY0_7 WENY0_8 WENY0_9 WENY0_10 WENY0_11 WENY0_12 WENY0_13
+  WENY0_14 WENY0_15 WENY0_16 WENY0_17 WENY0_18 WENY0_19 WENY0_20 WENY0_21
+  WENY0_22 WENY0_23 WENY0_24 WENY0_25 WENY0_26 WENY0_27 WENY0_28 WENY0_29
+  WENY0_30 WENY0_31 WENY0_32 WENY0_33 WENY0_34 WENY0_35 WENY1_0 WENY1_1
+  WENY1_2 WENY1_3 WENY1_4 WENY1_5 WENY1_6 WENY1_7 WENY1_8 WENY1_9 WENY1_10
+  WENY1_11 WENY1_12 WENY1_13 WENY1_14 WENY1_15 WENY1_16 WENY1_17 WENY1_18
+  WENY1_19 WENY1_20 WENY1_21 WENY1_22 WENY1_23 WENY1_24 WENY1_25 WENY1_26
+  WENY1_27 WENY1_28 WENY1_29 WENY1_30 WENY1_31 WENY1_32 WENY1_33 WENY1_34
+  WENY1_35
** sram464x144IO_RDM_R: 144 flat devices **
XR_RDM_1 D0_1 D1_1 DUM_SEL_D_L_72 DUM_SEL_D_L_68 DUM_SEL_TD_L_74
+  DUM_SEL_TD_L_70 Q0_1 Q1_1 SAO0_1 SAO1_1 TD0_1 TD1_1 TWEN0_1 TWEN1_1 VDDCE_1
+  VDDPE_1 VNWP_1 VPW_1 VSS_1 VSS_1 WEN0_1 WEN1_1 WENY0_1 WENY1_1
+  sram464x144RDM2X2
XR_RDM_10 D0_10 D1_10 DUM_SEL_D_L_4 DUM_SEL_D_R_0 DUM_SEL_TD_L_6
+  DUM_SEL_TD_R_2 Q0_10 Q1_10 SAO0_10 SAO1_10 TD0_10 TD1_10 TWEN0_10 TWEN1_10
+  VDDCE_10 VDDPE_10 VNWP_10 VPW_10 VSS_10 VSS_10 WEN0_10 WEN1_10 WENY0_10
+  WENY1_10 sram464x144RDM2X2
XR_RDM_11 D0_11 D1_11 DUM_SEL_D_L_8 DUM_SEL_D_L_4 DUM_SEL_TD_L_10
+  DUM_SEL_TD_L_6 Q0_11 Q1_11 SAO0_11 SAO1_11 TD0_11 TD1_11 TWEN0_11 TWEN1_11
+  VDDCE_11 VDDPE_11 VNWP_11 VPW_11 VSS_11 VSS_11 WEN0_11 WEN1_11 WENY0_11
+  WENY1_11 sram464x144RDM2X2
XR_RDM_12 D0_12 D1_12 DUM_SEL_D_L_20 DUM_SEL_D_L_8 DUM_SEL_TD_L_22
+  DUM_SEL_TD_L_10 Q0_12 Q1_12 SAO0_12 SAO1_12 TD0_12 TD1_12 TWEN0_12 TWEN1_12
+  VDDCE_12 VDDPE_12 VNWP_12 VPW_12 VSS_12 VSS_12 WEN0_12 WEN1_12 WENY0_12
+  WENY1_12 sram464x144RDM2X2
XR_RDM_13 D0_13 D1_13 DUM_SEL_D_L_28 DUM_SEL_D_L_20 DUM_SEL_TD_L_30
+  DUM_SEL_TD_L_22 Q0_13 Q1_13 SAO0_13 SAO1_13 TD0_13 TD1_13 TWEN0_13 TWEN1_13
+  VDDCE_13 VDDPE_13 VNWP_13 VPW_13 VSS_13 VSS_13 WEN0_13 WEN1_13 WENY0_13
+  WENY1_13 sram464x144RDM2X2
XR_RDM_14 D0_14 D1_14 DUM_SEL_D_L_36 DUM_SEL_D_L_28 DUM_SEL_TD_L_38
+  DUM_SEL_TD_L_30 Q0_14 Q1_14 SAO0_14 SAO1_14 TD0_14 TD1_14 TWEN0_14 TWEN1_14
+  VDDCE_14 VDDPE_14 VNWP_14 VPW_14 VSS_14 VSS_14 WEN0_14 WEN1_14 WENY0_14
+  WENY1_14 sram464x144RDM2X2
XR_RDM_15 D0_15 D1_15 DUM_SEL_D_L_44 DUM_SEL_D_L_36 DUM_SEL_TD_L_46
+  DUM_SEL_TD_L_38 Q0_15 Q1_15 SAO0_15 SAO1_15 TD0_15 TD1_15 TWEN0_15 TWEN1_15
+  VDDCE_15 VDDPE_15 VNWP_15 VPW_15 VSS_15 VSS_15 WEN0_15 WEN1_15 WENY0_15
+  WENY1_15 sram464x144RDM2X2
XR_RDM_16 D0_16 D1_16 DUM_SEL_D_L_52 DUM_SEL_D_L_44 DUM_SEL_TD_L_54
+  DUM_SEL_TD_L_46 Q0_16 Q1_16 SAO0_16 SAO1_16 TD0_16 TD1_16 TWEN0_16 TWEN1_16
+  VDDCE_16 VDDPE_16 VNWP_16 VPW_16 VSS_16 VSS_16 WEN0_16 WEN1_16 WENY0_16
+  WENY1_16 sram464x144RDM2X2
XR_RDM_17 D0_17 D1_17 DUM_SEL_D_L_56 DUM_SEL_D_L_52 DUM_SEL_TD_L_58
+  DUM_SEL_TD_L_54 Q0_17 Q1_17 SAO0_17 SAO1_17 TD0_17 TD1_17 TWEN0_17 TWEN1_17
+  VDDCE_17 VDDPE_17 VNWP_17 VPW_17 VSS_17 VSS_17 WEN0_17 WEN1_17 WENY0_17
+  WENY1_17 sram464x144RDM2X2
XR_RDM_18 D0_18 D1_18 DUM_SEL_D_L_60 DUM_SEL_D_L_56 DUM_SEL_TD_L_62
+  DUM_SEL_TD_L_58 Q0_18 Q1_18 SAO0_18 SAO1_18 TD0_18 TD1_18 TWEN0_18 TWEN1_18
+  VDDCE_18 VDDPE_18 VNWP_18 VPW_18 VSS_18 VSS_18 WEN0_18 WEN1_18 WENY0_18
+  WENY1_18 sram464x144RDM2X2
XR_RDM_19 D0_19 D1_19 DUM_SEL_D_L_64 DUM_SEL_D_L_60 DUM_SEL_TD_L_66
+  DUM_SEL_TD_L_62 Q0_19 Q1_19 SAO0_19 SAO1_19 TD0_19 TD1_19 TWEN0_19 TWEN1_19
+  VDDCE_19 VDDPE_19 VNWP_19 VPW_19 VSS_19 VSS_19 WEN0_19 WEN1_19 WENY0_19
+  WENY1_19 sram464x144RDM2X2
XR_RDM_2 D0_2 D1_2 DUM_SEL_D_L_76 DUM_SEL_D_L_72 DUM_SEL_TD_L_78
+  DUM_SEL_TD_L_74 Q0_2 Q1_2 SAO0_2 SAO1_2 TD0_2 TD1_2 TWEN0_2 TWEN1_2 VDDCE_2
+  VDDPE_2 VNWP_2 VPW_2 VSS_2 VSS_2 WEN0_2 WEN1_2 WENY0_2 WENY1_2
+  sram464x144RDM2X2
XR_RDM_20 D0_20 D1_20 DUM_SEL_D_L_104 DUM_SEL_D_L_64 DUM_SEL_TD_L_106
+  DUM_SEL_TD_L_66 Q0_20 Q1_20 SAO0_20 SAO1_20 TD0_20 TD1_20 TWEN0_20 TWEN1_20
+  VDDCE_20 VDDPE_20 VNWP_20 VPW_20 VSS_20 VSS_20 WEN0_20 WEN1_20 WENY0_20
+  WENY1_20 sram464x144RDM2X2
XR_RDM_21 D0_21 D1_21 DUM_SEL_D_L_108 DUM_SEL_D_L_104 DUM_SEL_TD_L_110
+  DUM_SEL_TD_L_106 Q0_21 Q1_21 SAO0_21 SAO1_21 TD0_21 TD1_21 TWEN0_21
+  TWEN1_21 VDDCE_21 VDDPE_21 VNWP_21 VPW_21 VSS_21 VSS_21 WEN0_21 WEN1_21
+  WENY0_21 WENY1_21 sram464x144RDM2X2
XR_RDM_22 D0_22 D1_22 DUM_SEL_D_L_112 DUM_SEL_D_L_108 DUM_SEL_TD_L_114
+  DUM_SEL_TD_L_110 Q0_22 Q1_22 SAO0_22 SAO1_22 TD0_22 TD1_22 TWEN0_22
+  TWEN1_22 VDDCE_22 VDDPE_22 VNWP_22 VPW_22 VSS_22 VSS_22 WEN0_22 WEN1_22
+  WENY0_22 WENY1_22 sram464x144RDM2X2
XR_RDM_23 D0_23 D1_23 DUM_SEL_D_L_116 DUM_SEL_D_L_112 DUM_SEL_TD_L_118
+  DUM_SEL_TD_L_114 Q0_23 Q1_23 SAO0_23 SAO1_23 TD0_23 TD1_23 TWEN0_23
+  TWEN1_23 VDDCE_23 VDDPE_23 VNWP_23 VPW_23 VSS_23 VSS_23 WEN0_23 WEN1_23
+  WENY0_23 WENY1_23 sram464x144RDM2X2
XR_RDM_24 D0_24 D1_24 DUM_SEL_D_L_120 DUM_SEL_D_L_116 DUM_SEL_TD_L_122
+  DUM_SEL_TD_L_118 Q0_24 Q1_24 SAO0_24 SAO1_24 TD0_24 TD1_24 TWEN0_24
+  TWEN1_24 VDDCE_24 VDDPE_24 VNWP_24 VPW_24 VSS_24 VSS_24 WEN0_24 WEN1_24
+  WENY0_24 WENY1_24 sram464x144RDM2X2
XR_RDM_25 D0_25 D1_25 DUM_SEL_D_L_124 DUM_SEL_D_L_120 DUM_SEL_TD_L_126
+  DUM_SEL_TD_L_122 Q0_25 Q1_25 SAO0_25 SAO1_25 TD0_25 TD1_25 TWEN0_25
+  TWEN1_25 VDDCE_25 VDDPE_25 VNWP_25 VPW_25 VSS_25 VSS_25 WEN0_25 WEN1_25
+  WENY0_25 WENY1_25 sram464x144RDM2X2
XR_RDM_26 D0_26 D1_26 DUM_SEL_D_L_128 DUM_SEL_D_L_124 DUM_SEL_TD_L_130
+  DUM_SEL_TD_L_126 Q0_26 Q1_26 SAO0_26 SAO1_26 TD0_26 TD1_26 TWEN0_26
+  TWEN1_26 VDDCE_26 VDDPE_26 VNWP_26 VPW_26 VSS_26 VSS_26 WEN0_26 WEN1_26
+  WENY0_26 WENY1_26 sram464x144RDM2X2
XR_RDM_27 D0_27 D1_27 DUM_SEL_D_L_132 DUM_SEL_D_L_128 DUM_SEL_TD_L_134
+  DUM_SEL_TD_L_130 Q0_27 Q1_27 SAO0_27 SAO1_27 TD0_27 TD1_27 TWEN0_27
+  TWEN1_27 VDDCE_27 VDDPE_27 VNWP_27 VPW_27 VSS_27 VSS_27 WEN0_27 WEN1_27
+  WENY0_27 WENY1_27 sram464x144RDM2X2
XR_RDM_28 D0_28 D1_28 DUM_SEL_D_L_136 DUM_SEL_D_L_132 DUM_SEL_TD_L_138
+  DUM_SEL_TD_L_134 Q0_28 Q1_28 SAO0_28 SAO1_28 TD0_28 TD1_28 TWEN0_28
+  TWEN1_28 VDDCE_28 VDDPE_28 VNWP_28 VPW_28 VSS_28 VSS_28 WEN0_28 WEN1_28
+  WENY0_28 WENY1_28 sram464x144RDM2X2
XR_RDM_29 D0_29 D1_29 DUM_SEL_D_R_12 DUM_SEL_D_L_136 DUM_SEL_TD_R_14
+  DUM_SEL_TD_L_138 Q0_29 Q1_29 SAO0_29 SAO1_29 TD0_29 TD1_29 TWEN0_29
+  TWEN1_29 VDDCE_29 VDDPE_29 VNWP_29 VPW_29 VSS_29 VSS_29 WEN0_29 WEN1_29
+  WENY0_29 WENY1_29 sram464x144RDM2X2
XR_RDM_3 D0_3 D1_3 DUM_SEL_D_L_80 DUM_SEL_D_L_76 DUM_SEL_TD_L_82
+  DUM_SEL_TD_L_78 Q0_3 Q1_3 SAO0_3 SAO1_3 TD0_3 TD1_3 TWEN0_3 TWEN1_3 VDDCE_3
+  VDDPE_3 VNWP_3 VPW_3 VSS_3 VSS_3 WEN0_3 WEN1_3 WENY0_3 WENY1_3
+  sram464x144RDM2X2
XR_RDM_30 D0_30 D1_30 DUM_SEL_D_L_16 DUM_SEL_D_R_12 DUM_SEL_TD_L_18
+  DUM_SEL_TD_R_14 Q0_30 Q1_30 SAO0_30 SAO1_30 TD0_30 TD1_30 TWEN0_30 TWEN1_30
+  VDDCE_30 VDDPE_30 VNWP_30 VPW_30 VSS_30 VSS_30 WEN0_30 WEN1_30 WENY0_30
+  WENY1_30 sram464x144RDM2X2
XR_RDM_31 D0_31 D1_31 DUM_SEL_D_L_24 DUM_SEL_D_L_16 DUM_SEL_TD_L_26
+  DUM_SEL_TD_L_18 Q0_31 Q1_31 SAO0_31 SAO1_31 TD0_31 TD1_31 TWEN0_31 TWEN1_31
+  VDDCE_31 VDDPE_31 VNWP_31 VPW_31 VSS_31 VSS_31 WEN0_31 WEN1_31 WENY0_31
+  WENY1_31 sram464x144RDM2X2
XR_RDM_32 D0_32 D1_32 DUM_SEL_D_L_32 DUM_SEL_D_L_24 DUM_SEL_TD_L_34
+  DUM_SEL_TD_L_26 Q0_32 Q1_32 SAO0_32 SAO1_32 TD0_32 TD1_32 TWEN0_32 TWEN1_32
+  VDDCE_32 VDDPE_32 VNWP_32 VPW_32 VSS_32 VSS_32 WEN0_32 WEN1_32 WENY0_32
+  WENY1_32 sram464x144RDM2X2
XR_RDM_33 D0_33 D1_33 DUM_SEL_D_L_40 DUM_SEL_D_L_32 DUM_SEL_TD_L_42
+  DUM_SEL_TD_L_34 Q0_33 Q1_33 SAO0_33 SAO1_33 TD0_33 TD1_33 TWEN0_33 TWEN1_33
+  VDDCE_33 VDDPE_33 VNWP_33 VPW_33 VSS_33 VSS_33 WEN0_33 WEN1_33 WENY0_33
+  WENY1_33 sram464x144RDM2X2
XR_RDM_34 D0_34 D1_34 DUM_SEL_D_L_48 DUM_SEL_D_L_40 DUM_SEL_TD_L_50
+  DUM_SEL_TD_L_42 Q0_34 Q1_34 SAO0_34 SAO1_34 TD0_34 TD1_34 TWEN0_34 TWEN1_34
+  VDDCE_34 VDDPE_34 VNWP_34 VPW_34 VSS_34 VSS_34 WEN0_34 WEN1_34 WENY0_34
+  WENY1_34 sram464x144RDM2X2
XR_RDM_4 D0_4 D1_4 DUM_SEL_D_L_84 DUM_SEL_D_L_80 DUM_SEL_TD_L_86
+  DUM_SEL_TD_L_82 Q0_4 Q1_4 SAO0_4 SAO1_4 TD0_4 TD1_4 TWEN0_4 TWEN1_4 VDDCE_4
+  VDDPE_4 VNWP_4 VPW_4 VSS_4 VSS_4 WEN0_4 WEN1_4 WENY0_4 WENY1_4
+  sram464x144RDM2X2
XR_RDM_5 D0_5 D1_5 DUM_SEL_D_L_88 DUM_SEL_D_L_84 DUM_SEL_TD_L_90
+  DUM_SEL_TD_L_86 Q0_5 Q1_5 SAO0_5 SAO1_5 TD0_5 TD1_5 TWEN0_5 TWEN1_5 VDDCE_5
+  VDDPE_5 VNWP_5 VPW_5 VSS_5 VSS_5 WEN0_5 WEN1_5 WENY0_5 WENY1_5
+  sram464x144RDM2X2
XR_RDM_6 D0_6 D1_6 DUM_SEL_D_L_92 DUM_SEL_D_L_88 DUM_SEL_TD_L_94
+  DUM_SEL_TD_L_90 Q0_6 Q1_6 SAO0_6 SAO1_6 TD0_6 TD1_6 TWEN0_6 TWEN1_6 VDDCE_6
+  VDDPE_6 VNWP_6 VPW_6 VSS_6 VSS_6 WEN0_6 WEN1_6 WENY0_6 WENY1_6
+  sram464x144RDM2X2
XR_RDM_7 D0_7 D1_7 DUM_SEL_D_L_96 DUM_SEL_D_L_92 DUM_SEL_TD_L_98
+  DUM_SEL_TD_L_94 Q0_7 Q1_7 SAO0_7 SAO1_7 TD0_7 TD1_7 TWEN0_7 TWEN1_7 VDDCE_7
+  VDDPE_7 VNWP_7 VPW_7 VSS_7 VSS_7 WEN0_7 WEN1_7 WENY0_7 WENY1_7
+  sram464x144RDM2X2
XR_RDM_8 D0_8 D1_8 DUM_SEL_D_L_100 DUM_SEL_D_L_96 DUM_SEL_TD_L_102
+  DUM_SEL_TD_L_98 Q0_8 Q1_8 SAO0_8 SAO1_8 TD0_8 TD1_8 TWEN0_8 TWEN1_8 VDDCE_8
+  VDDPE_8 VNWP_8 VPW_8 VSS_8 VSS_8 WEN0_8 WEN1_8 WENY0_8 WENY1_8
+  sram464x144RDM2X2
XR_RDM_9 D0_9 D1_9 DUM_SEL_D_R_0 DUM_SEL_D_L_100 DUM_SEL_TD_R_2
+  DUM_SEL_TD_L_102 Q0_9 Q1_9 SAO0_9 SAO1_9 TD0_9 TD1_9 TWEN0_9 TWEN1_9
+  VDDCE_9 VDDPE_9 VNWP_9 VPW_9 VSS_9 VSS_9 WEN0_9 WEN1_9 WENY0_9 WENY1_9
+  sram464x144RDM2X2
XR_RDM_L D0_0 D1_0 DUM_SEL_D_L_68 DUM_SEL_D_R DUM_SEL_TD_L_70 DUM_SEL_TD_R
+  Q0_0 Q1_0 SAO0_0 SAO1_0 TD0_0 TD1_0 TWEN0_0 TWEN1_0 VDDCE_0 VDDPE_0 VNWP_0
+  VPW_0 VSS_0 VSS_0 WEN0_0 WEN1_0 WENY0_0 WENY1_0 sram464x144RDM2X2
XR_RDM_R D0_35 D1_35 DUM_SEL_D_L DUM_SEL_D_L_48 DUM_SEL_TD_L DUM_SEL_TD_L_50
+  Q0_35 Q1_35 SAO0_35 SAO1_35 TD0_35 TD1_35 TWEN0_35 TWEN1_35 VDDCE_35
+  VDDPE_35 VNWP_35 VPW_35 VSS_35 VSS_35 WEN0_35 WEN1_35 WENY0_35 WENY1_35
+  sram464x144RDM2X2
.ENDS sram464x144IO_RDM_R
****
.SUBCKT sram464x144IOTOPCAP_R BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5
+  BL[0]_6 BL[0]_7 BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13
+  BL[0]_14 BL[0]_15 BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21
+  BL[0]_22 BL[0]_23 BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29
+  BL[0]_30 BL[0]_31 BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1
+  BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10
+  BL[1]_11 BL[1]_12 BL[1]_13 BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18
+  BL[1]_19 BL[1]_20 BL[1]_21 BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26
+  BL[1]_27 BL[1]_28 BL[1]_29 BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34
+  BL[1]_35 BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7
+  BL[2]_8 BL[2]_9 BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15
+  BL[2]_16 BL[2]_17 BL[2]_18 BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23
+  BL[2]_24 BL[2]_25 BL[2]_26 BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31
+  BL[2]_32 BL[2]_33 BL[2]_34 BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4
+  BL[3]_5 BL[3]_6 BL[3]_7 BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13
+  BL[3]_14 BL[3]_15 BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21
+  BL[3]_22 BL[3]_23 BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29
+  BL[3]_30 BL[3]_31 BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1
+  NBL[0]_2 NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9
+  NBL[0]_10 NBL[0]_11 NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16
+  NBL[0]_17 NBL[0]_18 NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23
+  NBL[0]_24 NBL[0]_25 NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30
+  NBL[0]_31 NBL[0]_32 NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1
+  NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9
+  NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16
+  NBL[1]_17 NBL[1]_18 NBL[1]_19 NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23
+  NBL[1]_24 NBL[1]_25 NBL[1]_26 NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30
+  NBL[1]_31 NBL[1]_32 NBL[1]_33 NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1
+  NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9
+  NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13 NBL[2]_14 NBL[2]_15 NBL[2]_16
+  NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20 NBL[2]_21 NBL[2]_22 NBL[2]_23
+  NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27 NBL[2]_28 NBL[2]_29 NBL[2]_30
+  NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34 NBL[2]_35 NBL[3]_0 NBL[3]_1
+  NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 NBL[3]_8 NBL[3]_9
+  NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13 NBL[3]_14 NBL[3]_15 NBL[3]_16
+  NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20 NBL[3]_21 NBL[3]_22 NBL[3]_23
+  NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27 NBL[3]_28 NBL[3]_29 NBL[3]_30
+  NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34 NBL[3]_35 VDDC VDDPE_0 VDDPE_1
+  VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8 VDDPE_9 VDDPE_10
+  VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16 VDDPE_17 VDDPE_18
+  VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24 VDDPE_25 VDDPE_26
+  VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32 VDDPE_33 VDDPE_34
+  VDDPE_35 VPW
** sram464x144IOTOPCAP_R: 1152 flat devices **
XIOTOPCAP_L0 BL[0]_0 BL[1]_0 BL[2]_0 BL[3]_0 NBL[0]_0 NBL[1]_0 NBL[2]_0
+  NBL[3]_0 VDDC VDDC VDDPE_0 VDDC VPW VPW sram464x144CCHD4_TOPBOT
XIOTOPCAP_L1 BL[0]_1 BL[1]_1 BL[2]_1 BL[3]_1 NBL[0]_1 NBL[1]_1 NBL[2]_1
+  NBL[3]_1 VDDC VDDC VDDPE_1 VDDC VPW VPW sram464x144CCHD4_TOPBOT
XIOTOPCAP_L10 BL[0]_10 BL[1]_10 BL[2]_10 BL[3]_10 NBL[0]_10 NBL[1]_10
+  NBL[2]_10 NBL[3]_10 VDDC VDDC VDDPE_10 VDDC VPW VPW sram464x144CCHD4_TOPBOT
XIOTOPCAP_L11 BL[0]_11 BL[1]_11 BL[2]_11 BL[3]_11 NBL[0]_11 NBL[1]_11
+  NBL[2]_11 NBL[3]_11 VDDC VDDC VDDPE_11 VDDC VPW VPW sram464x144CCHD4_TOPBOT
XIOTOPCAP_L12 BL[0]_12 BL[1]_12 BL[2]_12 BL[3]_12 NBL[0]_12 NBL[1]_12
+  NBL[2]_12 NBL[3]_12 VDDC VDDC VDDPE_12 VDDC VPW VPW sram464x144CCHD4_TOPBOT
XIOTOPCAP_L13 BL[0]_13 BL[1]_13 BL[2]_13 BL[3]_13 NBL[0]_13 NBL[1]_13
+  NBL[2]_13 NBL[3]_13 VDDC VDDC VDDPE_13 VDDC VPW VPW sram464x144CCHD4_TOPBOT
XIOTOPCAP_L14 BL[0]_14 BL[1]_14 BL[2]_14 BL[3]_14 NBL[0]_14 NBL[1]_14
+  NBL[2]_14 NBL[3]_14 VDDC VDDC VDDPE_14 VDDC VPW VPW sram464x144CCHD4_TOPBOT
XIOTOPCAP_L15 BL[0]_15 BL[1]_15 BL[2]_15 BL[3]_15 NBL[0]_15 NBL[1]_15
+  NBL[2]_15 NBL[3]_15 VDDC VDDC VDDPE_15 VDDC VPW VPW sram464x144CCHD4_TOPBOT
XIOTOPCAP_L16 BL[0]_16 BL[1]_16 BL[2]_16 BL[3]_16 NBL[0]_16 NBL[1]_16
+  NBL[2]_16 NBL[3]_16 VDDC VDDC VDDPE_16 VDDC VPW VPW sram464x144CCHD4_TOPBOT
XIOTOPCAP_L17 BL[0]_17 BL[1]_17 BL[2]_17 BL[3]_17 NBL[0]_17 NBL[1]_17
+  NBL[2]_17 NBL[3]_17 VDDC VDDC VDDPE_17 VDDC VPW VPW sram464x144CCHD4_TOPBOT
XIOTOPCAP_L18 BL[0]_18 BL[1]_18 BL[2]_18 BL[3]_18 NBL[0]_18 NBL[1]_18
+  NBL[2]_18 NBL[3]_18 VDDC VDDC VDDPE_18 VDDC VPW VPW sram464x144CCHD4_TOPBOT
XIOTOPCAP_L19 BL[0]_19 BL[1]_19 BL[2]_19 BL[3]_19 NBL[0]_19 NBL[1]_19
+  NBL[2]_19 NBL[3]_19 VDDC VDDC VDDPE_19 VDDC VPW VPW sram464x144CCHD4_TOPBOT
XIOTOPCAP_L2 BL[0]_2 BL[1]_2 BL[2]_2 BL[3]_2 NBL[0]_2 NBL[1]_2 NBL[2]_2
+  NBL[3]_2 VDDC VDDC VDDPE_2 VDDC VPW VPW sram464x144CCHD4_TOPBOT
XIOTOPCAP_L20 BL[0]_20 BL[1]_20 BL[2]_20 BL[3]_20 NBL[0]_20 NBL[1]_20
+  NBL[2]_20 NBL[3]_20 VDDC VDDC VDDPE_20 VDDC VPW VPW sram464x144CCHD4_TOPBOT
XIOTOPCAP_L21 BL[0]_21 BL[1]_21 BL[2]_21 BL[3]_21 NBL[0]_21 NBL[1]_21
+  NBL[2]_21 NBL[3]_21 VDDC VDDC VDDPE_21 VDDC VPW VPW sram464x144CCHD4_TOPBOT
XIOTOPCAP_L22 BL[0]_22 BL[1]_22 BL[2]_22 BL[3]_22 NBL[0]_22 NBL[1]_22
+  NBL[2]_22 NBL[3]_22 VDDC VDDC VDDPE_22 VDDC VPW VPW sram464x144CCHD4_TOPBOT
XIOTOPCAP_L23 BL[0]_23 BL[1]_23 BL[2]_23 BL[3]_23 NBL[0]_23 NBL[1]_23
+  NBL[2]_23 NBL[3]_23 VDDC VDDC VDDPE_23 VDDC VPW VPW sram464x144CCHD4_TOPBOT
XIOTOPCAP_L24 BL[0]_24 BL[1]_24 BL[2]_24 BL[3]_24 NBL[0]_24 NBL[1]_24
+  NBL[2]_24 NBL[3]_24 VDDC VDDC VDDPE_24 VDDC VPW VPW sram464x144CCHD4_TOPBOT
XIOTOPCAP_L25 BL[0]_25 BL[1]_25 BL[2]_25 BL[3]_25 NBL[0]_25 NBL[1]_25
+  NBL[2]_25 NBL[3]_25 VDDC VDDC VDDPE_25 VDDC VPW VPW sram464x144CCHD4_TOPBOT
XIOTOPCAP_L26 BL[0]_26 BL[1]_26 BL[2]_26 BL[3]_26 NBL[0]_26 NBL[1]_26
+  NBL[2]_26 NBL[3]_26 VDDC VDDC VDDPE_26 VDDC VPW VPW sram464x144CCHD4_TOPBOT
XIOTOPCAP_L27 BL[0]_27 BL[1]_27 BL[2]_27 BL[3]_27 NBL[0]_27 NBL[1]_27
+  NBL[2]_27 NBL[3]_27 VDDC VDDC VDDPE_27 VDDC VPW VPW sram464x144CCHD4_TOPBOT
XIOTOPCAP_L28 BL[0]_28 BL[1]_28 BL[2]_28 BL[3]_28 NBL[0]_28 NBL[1]_28
+  NBL[2]_28 NBL[3]_28 VDDC VDDC VDDPE_28 VDDC VPW VPW sram464x144CCHD4_TOPBOT
XIOTOPCAP_L29 BL[0]_29 BL[1]_29 BL[2]_29 BL[3]_29 NBL[0]_29 NBL[1]_29
+  NBL[2]_29 NBL[3]_29 VDDC VDDC VDDPE_29 VDDC VPW VPW sram464x144CCHD4_TOPBOT
XIOTOPCAP_L3 BL[0]_3 BL[1]_3 BL[2]_3 BL[3]_3 NBL[0]_3 NBL[1]_3 NBL[2]_3
+  NBL[3]_3 VDDC VDDC VDDPE_3 VDDC VPW VPW sram464x144CCHD4_TOPBOT
XIOTOPCAP_L30 BL[0]_30 BL[1]_30 BL[2]_30 BL[3]_30 NBL[0]_30 NBL[1]_30
+  NBL[2]_30 NBL[3]_30 VDDC VDDC VDDPE_30 VDDC VPW VPW sram464x144CCHD4_TOPBOT
XIOTOPCAP_L31 BL[0]_31 BL[1]_31 BL[2]_31 BL[3]_31 NBL[0]_31 NBL[1]_31
+  NBL[2]_31 NBL[3]_31 VDDC VDDC VDDPE_31 VDDC VPW VPW sram464x144CCHD4_TOPBOT
XIOTOPCAP_L32 BL[0]_32 BL[1]_32 BL[2]_32 BL[3]_32 NBL[0]_32 NBL[1]_32
+  NBL[2]_32 NBL[3]_32 VDDC VDDC VDDPE_32 VDDC VPW VPW sram464x144CCHD4_TOPBOT
XIOTOPCAP_L33 BL[0]_33 BL[1]_33 BL[2]_33 BL[3]_33 NBL[0]_33 NBL[1]_33
+  NBL[2]_33 NBL[3]_33 VDDC VDDC VDDPE_33 VDDC VPW VPW sram464x144CCHD4_TOPBOT
XIOTOPCAP_L34 BL[0]_34 BL[1]_34 BL[2]_34 BL[3]_34 NBL[0]_34 NBL[1]_34
+  NBL[2]_34 NBL[3]_34 VDDC VDDC VDDPE_34 VDDC VPW VPW sram464x144CCHD4_TOPBOT
XIOTOPCAP_L35 BL[0]_35 BL[1]_35 BL[2]_35 BL[3]_35 NBL[0]_35 NBL[1]_35
+  NBL[2]_35 NBL[3]_35 VDDC VDDC VDDPE_35 VDDC VPW VPW sram464x144CCHD4_TOPBOT
XIOTOPCAP_L4 BL[0]_4 BL[1]_4 BL[2]_4 BL[3]_4 NBL[0]_4 NBL[1]_4 NBL[2]_4
+  NBL[3]_4 VDDC VDDC VDDPE_4 VDDC VPW VPW sram464x144CCHD4_TOPBOT
XIOTOPCAP_L5 BL[0]_5 BL[1]_5 BL[2]_5 BL[3]_5 NBL[0]_5 NBL[1]_5 NBL[2]_5
+  NBL[3]_5 VDDC VDDC VDDPE_5 VDDC VPW VPW sram464x144CCHD4_TOPBOT
XIOTOPCAP_L6 BL[0]_6 BL[1]_6 BL[2]_6 BL[3]_6 NBL[0]_6 NBL[1]_6 NBL[2]_6
+  NBL[3]_6 VDDC VDDC VDDPE_6 VDDC VPW VPW sram464x144CCHD4_TOPBOT
XIOTOPCAP_L7 BL[0]_7 BL[1]_7 BL[2]_7 BL[3]_7 NBL[0]_7 NBL[1]_7 NBL[2]_7
+  NBL[3]_7 VDDC VDDC VDDPE_7 VDDC VPW VPW sram464x144CCHD4_TOPBOT
XIOTOPCAP_L8 BL[0]_8 BL[1]_8 BL[2]_8 BL[3]_8 NBL[0]_8 NBL[1]_8 NBL[2]_8
+  NBL[3]_8 VDDC VDDC VDDPE_8 VDDC VPW VPW sram464x144CCHD4_TOPBOT
XIOTOPCAP_L9 BL[0]_9 BL[1]_9 BL[2]_9 BL[3]_9 NBL[0]_9 NBL[1]_9 NBL[2]_9
+  NBL[3]_9 VDDC VDDC VDDPE_9 VDDC VPW VPW sram464x144CCHD4_TOPBOT
.ENDS sram464x144IOTOPCAP_R
****
.SUBCKT sram464x144IO_ROW_R BLPRECH BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4
+  BL[0]_5 BL[0]_6 BL[0]_7 BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13
+  BL[0]_14 BL[0]_15 BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21
+  BL[0]_22 BL[0]_23 BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29
+  BL[0]_30 BL[0]_31 BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1
+  BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10
+  BL[1]_11 BL[1]_12 BL[1]_13 BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18
+  BL[1]_19 BL[1]_20 BL[1]_21 BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26
+  BL[1]_27 BL[1]_28 BL[1]_29 BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34
+  BL[1]_35 BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7
+  BL[2]_8 BL[2]_9 BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15
+  BL[2]_16 BL[2]_17 BL[2]_18 BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23
+  BL[2]_24 BL[2]_25 BL[2]_26 BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31
+  BL[2]_32 BL[2]_33 BL[2]_34 BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4
+  BL[3]_5 BL[3]_6 BL[3]_7 BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13
+  BL[3]_14 BL[3]_15 BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21
+  BL[3]_22 BL[3]_23 BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29
+  BL[3]_30 BL[3]_31 BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 D0_0 D0_1 D0_2 D0_3
+  D0_4 D0_5 D0_6 D0_7 D0_8 D0_9 D0_10 D0_11 D0_12 D0_13 D0_14 D0_15 D0_16
+  D0_17 D0_18 D0_19 D0_20 D0_21 D0_22 D0_23 D0_24 D0_25 D0_26 D0_27 D0_28
+  D0_29 D0_30 D0_31 D0_32 D0_33 D0_34 D0_35 D1_0 D1_1 D1_2 D1_3 D1_4 D1_5
+  D1_6 D1_7 D1_8 D1_9 D1_10 D1_11 D1_12 D1_13 D1_14 D1_15 D1_16 D1_17 D1_18
+  D1_19 D1_20 D1_21 D1_22 D1_23 D1_24 D1_25 D1_26 D1_27 D1_28 D1_29 D1_30
+  D1_31 D1_32 D1_33 D1_34 D1_35 DUM_SEL_D_R DUM_SEL_TD_R DWL LOG0_0 LOG0_1
+  NACT_CC NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6
+  NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11 NBL[0]_12 NBL[0]_13
+  NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18 NBL[0]_19 NBL[0]_20
+  NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25 NBL[0]_26 NBL[0]_27
+  NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32 NBL[0]_33 NBL[0]_34
+  NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6
+  NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13
+  NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19 NBL[1]_20
+  NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26 NBL[1]_27
+  NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33 NBL[1]_34
+  NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6
+  NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 NSAE NWCLK NYR0 NYR1 Q0_0 Q0_1 Q0_2 Q0_3 Q0_4 Q0_5 Q0_6 Q0_7 Q0_8
+  Q0_9 Q0_10 Q0_11 Q0_12 Q0_13 Q0_14 Q0_15 Q0_16 Q0_17 Q0_18 Q0_19 Q0_20
+  Q0_21 Q0_22 Q0_23 Q0_24 Q0_25 Q0_26 Q0_27 Q0_28 Q0_29 Q0_30 Q0_31 Q0_32
+  Q0_33 Q0_34 Q0_35 Q1_0 Q1_1 Q1_2 Q1_3 Q1_4 Q1_5 Q1_6 Q1_7 Q1_8 Q1_9 Q1_10
+  Q1_11 Q1_12 Q1_13 Q1_14 Q1_15 Q1_16 Q1_17 Q1_18 Q1_19 Q1_20 Q1_21 Q1_22
+  Q1_23 Q1_24 Q1_25 Q1_26 Q1_27 Q1_28 Q1_29 Q1_30 Q1_31 Q1_32 Q1_33 Q1_34
+  Q1_35 SAPRECH TD0_0 TD0_1 TD0_2 TD0_3 TD0_4 TD0_5 TD0_6 TD0_7 TD0_8 TD0_9
+  TD0_10 TD0_11 TD0_12 TD0_13 TD0_14 TD0_15 TD0_16 TD0_17 TD0_18 TD0_19
+  TD0_20 TD0_21 TD0_22 TD0_23 TD0_24 TD0_25 TD0_26 TD0_27 TD0_28 TD0_29
+  TD0_30 TD0_31 TD0_32 TD0_33 TD0_34 TD0_35 TD1_0 TD1_1 TD1_2 TD1_3 TD1_4
+  TD1_5 TD1_6 TD1_7 TD1_8 TD1_9 TD1_10 TD1_11 TD1_12 TD1_13 TD1_14 TD1_15
+  TD1_16 TD1_17 TD1_18 TD1_19 TD1_20 TD1_21 TD1_22 TD1_23 TD1_24 TD1_25
+  TD1_26 TD1_27 TD1_28 TD1_29 TD1_30 TD1_31 TD1_32 TD1_33 TD1_34 TD1_35
+  TWEN0_0 TWEN0_1 TWEN0_2 TWEN0_3 TWEN0_4 TWEN0_5 TWEN0_6 TWEN0_7 TWEN0_8
+  TWEN0_9 TWEN0_10 TWEN0_11 TWEN0_12 TWEN0_13 TWEN0_14 TWEN0_15 TWEN0_16
+  TWEN0_17 TWEN0_18 TWEN0_19 TWEN0_20 TWEN0_21 TWEN0_22 TWEN0_23 TWEN0_24
+  TWEN0_25 TWEN0_26 TWEN0_27 TWEN0_28 TWEN0_29 TWEN0_30 TWEN0_31 TWEN0_32
+  TWEN0_33 TWEN0_34 TWEN0_35 TWEN1_0 TWEN1_1 TWEN1_2 TWEN1_3 TWEN1_4 TWEN1_5
+  TWEN1_6 TWEN1_7 TWEN1_8 TWEN1_9 TWEN1_10 TWEN1_11 TWEN1_12 TWEN1_13
+  TWEN1_14 TWEN1_15 TWEN1_16 TWEN1_17 TWEN1_18 TWEN1_19 TWEN1_20 TWEN1_21
+  TWEN1_22 TWEN1_23 TWEN1_24 TWEN1_25 TWEN1_26 TWEN1_27 TWEN1_28 TWEN1_29
+  TWEN1_30 TWEN1_31 TWEN1_32 TWEN1_33 TWEN1_34 TWEN1_35 VDDC VDDPE VPW WEN0_0
+  WEN0_1 WEN0_2 WEN0_3 WEN0_4 WEN0_5 WEN0_6 WEN0_7 WEN0_8 WEN0_9 WEN0_10
+  WEN0_11 WEN0_12 WEN0_13 WEN0_14 WEN0_15 WEN0_16 WEN0_17 WEN0_18 WEN0_19
+  WEN0_20 WEN0_21 WEN0_22 WEN0_23 WEN0_24 WEN0_25 WEN0_26 WEN0_27 WEN0_28
+  WEN0_29 WEN0_30 WEN0_31 WEN0_32 WEN0_33 WEN0_34 WEN0_35 WEN1_0 WEN1_1
+  WEN1_2 WEN1_3 WEN1_4 WEN1_5 WEN1_6 WEN1_7 WEN1_8 WEN1_9 WEN1_10 WEN1_11
+  WEN1_12 WEN1_13 WEN1_14 WEN1_15 WEN1_16 WEN1_17 WEN1_18 WEN1_19 WEN1_20
+  WEN1_21 WEN1_22 WEN1_23 WEN1_24 WEN1_25 WEN1_26 WEN1_27 WEN1_28 WEN1_29
+  WEN1_30 WEN1_31 WEN1_32 WEN1_33 WEN1_34 WEN1_35 WENY0_0 WENY0_1 WENY0_2
+  WENY0_3 WENY0_4 WENY0_5 WENY0_6 WENY0_7 WENY0_8 WENY0_9 WENY0_10 WENY0_11
+  WENY0_12 WENY0_13 WENY0_14 WENY0_15 WENY0_16 WENY0_17 WENY0_18 WENY0_19
+  WENY0_20 WENY0_21 WENY0_22 WENY0_23 WENY0_24 WENY0_25 WENY0_26 WENY0_27
+  WENY0_28 WENY0_29 WENY0_30 WENY0_31 WENY0_32 WENY0_33 WENY0_34 WENY0_35
+  WENY1_0 WENY1_1 WENY1_2 WENY1_3 WENY1_4 WENY1_5 WENY1_6 WENY1_7 WENY1_8
+  WENY1_9 WENY1_10 WENY1_11 WENY1_12 WENY1_13 WENY1_14 WENY1_15 WENY1_16
+  WENY1_17 WENY1_18 WENY1_19 WENY1_20 WENY1_21 WENY1_22 WENY1_23 WENY1_24
+  WENY1_25 WENY1_26 WENY1_27 WENY1_28 WENY1_29 WENY1_30 WENY1_31 WENY1_32
+  WENY1_33 WENY1_34 WENY1_35 YW0 YW1
** sram464x144IO_ROW_R: 6089 flat devices **
XIO_CDM_ROW_R BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 BLPRECH D0_0 D0_1 D0_2 D0_3 D0_4 D0_5
+  D0_6 D0_7 D0_8 D0_9 D0_10 D0_11 D0_12 D0_13 D0_14 D0_15 D0_16 D0_17 D0_18
+  D0_19 D0_20 D0_21 D0_22 D0_23 D0_24 D0_25 D0_26 D0_27 D0_28 D0_29 D0_30
+  D0_31 D0_32 D0_33 D0_34 D0_35 D1_0 D1_1 D1_2 D1_3 D1_4 D1_5 D1_6 D1_7 D1_8
+  D1_9 D1_10 D1_11 D1_12 D1_13 D1_14 D1_15 D1_16 D1_17 D1_18 D1_19 D1_20
+  D1_21 D1_22 D1_23 D1_24 D1_25 D1_26 D1_27 D1_28 D1_29 D1_30 D1_31 D1_32
+  D1_33 D1_34 D1_35 TD1_0 TD1_1 TD1_2 TD1_3 TD1_4 TD1_5 TD1_6 TD1_7 TD1_8
+  TD1_9 TD1_10 TD1_11 TD1_12 TD1_13 TD1_14 TD1_15 TD1_16 TD1_17 TD1_18 TD1_19
+  TD1_20 TD1_21 TD1_22 TD1_23 TD1_24 TD1_25 TD1_26 TD1_27 TD1_28 TD1_29
+  TD1_30 TD1_31 TD1_32 TD1_33 TD1_34 TD1_35 WEN1_0 WEN1_1 WEN1_2 WEN1_3
+  WEN1_4 WEN1_5 WEN1_6 WEN1_7 WEN1_8 WEN1_9 WEN1_10 WEN1_11 WEN1_12 WEN1_13
+  WEN1_14 WEN1_15 WEN1_16 WEN1_17 WEN1_18 WEN1_19 WEN1_20 WEN1_21 WEN1_22
+  WEN1_23 WEN1_24 WEN1_25 WEN1_26 WEN1_27 WEN1_28 WEN1_29 WEN1_30 WEN1_31
+  WEN1_32 WEN1_33 WEN1_34 WEN1_35 TWEN1_0 TWEN1_1 TWEN1_2 TWEN1_3 TWEN1_4
+  TWEN1_5 TWEN1_6 TWEN1_7 TWEN1_8 TWEN1_9 TWEN1_10 TWEN1_11 TWEN1_12 TWEN1_13
+  TWEN1_14 TWEN1_15 TWEN1_16 TWEN1_17 TWEN1_18 TWEN1_19 TWEN1_20 TWEN1_21
+  TWEN1_22 TWEN1_23 TWEN1_24 TWEN1_25 TWEN1_26 TWEN1_27 TWEN1_28 TWEN1_29
+  TWEN1_30 TWEN1_31 TWEN1_32 TWEN1_33 TWEN1_34 TWEN1_35 WENY1_0 WENY1_1
+  WENY1_2 WENY1_3 WENY1_4 WENY1_5 WENY1_6 WENY1_7 WENY1_8 WENY1_9 WENY1_10
+  WENY1_11 WENY1_12 WENY1_13 WENY1_14 WENY1_15 WENY1_16 WENY1_17 WENY1_18
+  WENY1_19 WENY1_20 WENY1_21 WENY1_22 WENY1_23 WENY1_24 WENY1_25 WENY1_26
+  WENY1_27 WENY1_28 WENY1_29 WENY1_30 WENY1_31 WENY1_32 WENY1_33 WENY1_34
+  WENY1_35 WENY0_0 WENY0_1 WENY0_2 WENY0_3 WENY0_4 WENY0_5 WENY0_6 WENY0_7
+  WENY0_8 WENY0_9 WENY0_10 WENY0_11 WENY0_12 WENY0_13 WENY0_14 WENY0_15
+  WENY0_16 WENY0_17 WENY0_18 WENY0_19 WENY0_20 WENY0_21 WENY0_22 WENY0_23
+  WENY0_24 WENY0_25 WENY0_26 WENY0_27 WENY0_28 WENY0_29 WENY0_30 WENY0_31
+  WENY0_32 WENY0_33 WENY0_34 WENY0_35 TWEN0_0 TWEN0_1 TWEN0_2 TWEN0_3 TWEN0_4
+  TWEN0_5 TWEN0_6 TWEN0_7 TWEN0_8 TWEN0_9 TWEN0_10 TWEN0_11 TWEN0_12 TWEN0_13
+  TWEN0_14 TWEN0_15 TWEN0_16 TWEN0_17 TWEN0_18 TWEN0_19 TWEN0_20 TWEN0_21
+  TWEN0_22 TWEN0_23 TWEN0_24 TWEN0_25 TWEN0_26 TWEN0_27 TWEN0_28 TWEN0_29
+  TWEN0_30 TWEN0_31 TWEN0_32 TWEN0_33 TWEN0_34 TWEN0_35 WEN0_0 WEN0_1 WEN0_2
+  WEN0_3 WEN0_4 WEN0_5 WEN0_6 WEN0_7 WEN0_8 WEN0_9 WEN0_10 WEN0_11 WEN0_12
+  WEN0_13 WEN0_14 WEN0_15 WEN0_16 WEN0_17 WEN0_18 WEN0_19 WEN0_20 WEN0_21
+  WEN0_22 WEN0_23 WEN0_24 WEN0_25 WEN0_26 WEN0_27 WEN0_28 WEN0_29 WEN0_30
+  WEN0_31 WEN0_32 WEN0_33 WEN0_34 WEN0_35 TD0_0 TD0_1 TD0_2 TD0_3 TD0_4 TD0_5
+  TD0_6 TD0_7 TD0_8 TD0_9 TD0_10 TD0_11 TD0_12 TD0_13 TD0_14 TD0_15 TD0_16
+  TD0_17 TD0_18 TD0_19 TD0_20 TD0_21 TD0_22 TD0_23 TD0_24 TD0_25 TD0_26
+  TD0_27 TD0_28 TD0_29 TD0_30 TD0_31 TD0_32 TD0_33 TD0_34 TD0_35 DWL LOG0_1
+  NACT_CC NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6
+  NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11 NBL[0]_12 NBL[0]_13
+  NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18 NBL[0]_19 NBL[0]_20
+  NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25 NBL[0]_26 NBL[0]_27
+  NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32 NBL[0]_33 NBL[0]_34
+  NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6
+  NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13
+  NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19 NBL[1]_20
+  NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26 NBL[1]_27
+  NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33 NBL[1]_34
+  NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6
+  NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 NSAE NWCLK NYR0 NYR1 SAO0_0 SAO0_1 SAO0_2 SAO0_3 SAO0_4 SAO0_5
+  SAO0_6 SAO0_7 SAO0_8 SAO0_9 SAO0_10 SAO0_11 SAO0_12 SAO0_13 SAO0_14 SAO0_15
+  SAO0_16 SAO0_17 SAO0_18 SAO0_19 SAO0_20 SAO0_21 SAO0_22 SAO0_23 SAO0_24
+  SAO0_25 SAO0_26 SAO0_27 SAO0_28 SAO0_29 SAO0_30 SAO0_31 SAO0_32 SAO0_33
+  SAO0_34 SAO0_35 SAO1_0 SAO1_1 SAO1_2 SAO1_3 SAO1_4 SAO1_5 SAO1_6 SAO1_7
+  SAO1_8 SAO1_9 SAO1_10 SAO1_11 SAO1_12 SAO1_13 SAO1_14 SAO1_15 SAO1_16
+  SAO1_17 SAO1_18 SAO1_19 SAO1_20 SAO1_21 SAO1_22 SAO1_23 SAO1_24 SAO1_25
+  SAO1_26 SAO1_27 SAO1_28 SAO1_29 SAO1_30 SAO1_31 SAO1_32 SAO1_33 SAO1_34
+  SAO1_35 SAPRECH VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VPW YW0 YW1 sram464x144IOCDM_R
XIO_EDGE_R BLPRECH DUM_SEL_D DUM_SEL_TD DWL LOG0_0 LOG0_1 NACT_CC NSAE NWCLK
+  NYR0 NYR1 SAPRECH VDDC VDDC VDDPE VDDC VPW VPW YW0 YW1 sram464x144IOEDGE
XIO_RDM_ROW_R D0_0 D0_1 D0_2 D0_3 D0_4 D0_5 D0_6 D0_7 D0_8 D0_9 D0_10 D0_11
+  D0_12 D0_13 D0_14 D0_15 D0_16 D0_17 D0_18 D0_19 D0_20 D0_21 D0_22 D0_23
+  D0_24 D0_25 D0_26 D0_27 D0_28 D0_29 D0_30 D0_31 D0_32 D0_33 D0_34 D0_35
+  D1_0 D1_1 D1_2 D1_3 D1_4 D1_5 D1_6 D1_7 D1_8 D1_9 D1_10 D1_11 D1_12 D1_13
+  D1_14 D1_15 D1_16 D1_17 D1_18 D1_19 D1_20 D1_21 D1_22 D1_23 D1_24 D1_25
+  D1_26 D1_27 D1_28 D1_29 D1_30 D1_31 D1_32 D1_33 D1_34 D1_35 DUM_SEL_D
+  DUM_SEL_D_R DUM_SEL_TD DUM_SEL_TD_R Q0_0 Q0_1 Q0_2 Q0_3 Q0_4 Q0_5 Q0_6 Q0_7
+  Q0_8 Q0_9 Q0_10 Q0_11 Q0_12 Q0_13 Q0_14 Q0_15 Q0_16 Q0_17 Q0_18 Q0_19 Q0_20
+  Q0_21 Q0_22 Q0_23 Q0_24 Q0_25 Q0_26 Q0_27 Q0_28 Q0_29 Q0_30 Q0_31 Q0_32
+  Q0_33 Q0_34 Q0_35 Q1_0 Q1_1 Q1_2 Q1_3 Q1_4 Q1_5 Q1_6 Q1_7 Q1_8 Q1_9 Q1_10
+  Q1_11 Q1_12 Q1_13 Q1_14 Q1_15 Q1_16 Q1_17 Q1_18 Q1_19 Q1_20 Q1_21 Q1_22
+  Q1_23 Q1_24 Q1_25 Q1_26 Q1_27 Q1_28 Q1_29 Q1_30 Q1_31 Q1_32 Q1_33 Q1_34
+  Q1_35 SAO0_0 SAO0_1 SAO0_2 SAO0_3 SAO0_4 SAO0_5 SAO0_6 SAO0_7 SAO0_8 SAO0_9
+  SAO0_10 SAO0_11 SAO0_12 SAO0_13 SAO0_14 SAO0_15 SAO0_16 SAO0_17 SAO0_18
+  SAO0_19 SAO0_20 SAO0_21 SAO0_22 SAO0_23 SAO0_24 SAO0_25 SAO0_26 SAO0_27
+  SAO0_28 SAO0_29 SAO0_30 SAO0_31 SAO0_32 SAO0_33 SAO0_34 SAO0_35 SAO1_0
+  SAO1_1 SAO1_2 SAO1_3 SAO1_4 SAO1_5 SAO1_6 SAO1_7 SAO1_8 SAO1_9 SAO1_10
+  SAO1_11 SAO1_12 SAO1_13 SAO1_14 SAO1_15 SAO1_16 SAO1_17 SAO1_18 SAO1_19
+  SAO1_20 SAO1_21 SAO1_22 SAO1_23 SAO1_24 SAO1_25 SAO1_26 SAO1_27 SAO1_28
+  SAO1_29 SAO1_30 SAO1_31 SAO1_32 SAO1_33 SAO1_34 SAO1_35 TD0_0 TD0_1 TD0_2
+  TD0_3 TD0_4 TD0_5 TD0_6 TD0_7 TD0_8 TD0_9 TD0_10 TD0_11 TD0_12 TD0_13
+  TD0_14 TD0_15 TD0_16 TD0_17 TD0_18 TD0_19 TD0_20 TD0_21 TD0_22 TD0_23
+  TD0_24 TD0_25 TD0_26 TD0_27 TD0_28 TD0_29 TD0_30 TD0_31 TD0_32 TD0_33
+  TD0_34 TD0_35 TD1_0 TD1_1 TD1_2 TD1_3 TD1_4 TD1_5 TD1_6 TD1_7 TD1_8 TD1_9
+  TD1_10 TD1_11 TD1_12 TD1_13 TD1_14 TD1_15 TD1_16 TD1_17 TD1_18 TD1_19
+  TD1_20 TD1_21 TD1_22 TD1_23 TD1_24 TD1_25 TD1_26 TD1_27 TD1_28 TD1_29
+  TD1_30 TD1_31 TD1_32 TD1_33 TD1_34 TD1_35 TWEN0_0 TWEN0_1 TWEN0_2 TWEN0_3
+  TWEN0_4 TWEN0_5 TWEN0_6 TWEN0_7 TWEN0_8 TWEN0_9 TWEN0_10 TWEN0_11 TWEN0_12
+  TWEN0_13 TWEN0_14 TWEN0_15 TWEN0_16 TWEN0_17 TWEN0_18 TWEN0_19 TWEN0_20
+  TWEN0_21 TWEN0_22 TWEN0_23 TWEN0_24 TWEN0_25 TWEN0_26 TWEN0_27 TWEN0_28
+  TWEN0_29 TWEN0_30 TWEN0_31 TWEN0_32 TWEN0_33 TWEN0_34 TWEN0_35 TWEN1_0
+  TWEN1_1 TWEN1_2 TWEN1_3 TWEN1_4 TWEN1_5 TWEN1_6 TWEN1_7 TWEN1_8 TWEN1_9
+  TWEN1_10 TWEN1_11 TWEN1_12 TWEN1_13 TWEN1_14 TWEN1_15 TWEN1_16 TWEN1_17
+  TWEN1_18 TWEN1_19 TWEN1_20 TWEN1_21 TWEN1_22 TWEN1_23 TWEN1_24 TWEN1_25
+  TWEN1_26 TWEN1_27 TWEN1_28 TWEN1_29 TWEN1_30 TWEN1_31 TWEN1_32 TWEN1_33
+  TWEN1_34 TWEN1_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE VDDPE VDDPE VDDPE
+  VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE
+  VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE
+  VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE
+  VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE
+  VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE
+  VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW VPW VPW VPW VPW VPW WEN0_0 WEN0_1 WEN0_2 WEN0_3 WEN0_4 WEN0_5
+  WEN0_6 WEN0_7 WEN0_8 WEN0_9 WEN0_10 WEN0_11 WEN0_12 WEN0_13 WEN0_14 WEN0_15
+  WEN0_16 WEN0_17 WEN0_18 WEN0_19 WEN0_20 WEN0_21 WEN0_22 WEN0_23 WEN0_24
+  WEN0_25 WEN0_26 WEN0_27 WEN0_28 WEN0_29 WEN0_30 WEN0_31 WEN0_32 WEN0_33
+  WEN0_34 WEN0_35 WEN1_0 WEN1_1 WEN1_2 WEN1_3 WEN1_4 WEN1_5 WEN1_6 WEN1_7
+  WEN1_8 WEN1_9 WEN1_10 WEN1_11 WEN1_12 WEN1_13 WEN1_14 WEN1_15 WEN1_16
+  WEN1_17 WEN1_18 WEN1_19 WEN1_20 WEN1_21 WEN1_22 WEN1_23 WEN1_24 WEN1_25
+  WEN1_26 WEN1_27 WEN1_28 WEN1_29 WEN1_30 WEN1_31 WEN1_32 WEN1_33 WEN1_34
+  WEN1_35 WENY0_0 WENY0_1 WENY0_2 WENY0_3 WENY0_4 WENY0_5 WENY0_6 WENY0_7
+  WENY0_8 WENY0_9 WENY0_10 WENY0_11 WENY0_12 WENY0_13 WENY0_14 WENY0_15
+  WENY0_16 WENY0_17 WENY0_18 WENY0_19 WENY0_20 WENY0_21 WENY0_22 WENY0_23
+  WENY0_24 WENY0_25 WENY0_26 WENY0_27 WENY0_28 WENY0_29 WENY0_30 WENY0_31
+  WENY0_32 WENY0_33 WENY0_34 WENY0_35 WENY1_0 WENY1_1 WENY1_2 WENY1_3 WENY1_4
+  WENY1_5 WENY1_6 WENY1_7 WENY1_8 WENY1_9 WENY1_10 WENY1_11 WENY1_12 WENY1_13
+  WENY1_14 WENY1_15 WENY1_16 WENY1_17 WENY1_18 WENY1_19 WENY1_20 WENY1_21
+  WENY1_22 WENY1_23 WENY1_24 WENY1_25 WENY1_26 WENY1_27 WENY1_28 WENY1_29
+  WENY1_30 WENY1_31 WENY1_32 WENY1_33 WENY1_34 WENY1_35 sram464x144IO_RDM_R
XIO_TOPCAP_ROW_R BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6
+  BL[0]_7 BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14
+  BL[0]_15 BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22
+  BL[0]_23 BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30
+  BL[0]_31 BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2
+  BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11
+  BL[1]_12 BL[1]_13 BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19
+  BL[1]_20 BL[1]_21 BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27
+  BL[1]_28 BL[1]_29 BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35
+  BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8
+  BL[2]_9 BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16
+  BL[2]_17 BL[2]_18 BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24
+  BL[2]_25 BL[2]_26 BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32
+  BL[2]_33 BL[2]_34 BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5
+  BL[3]_6 BL[3]_7 BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13
+  BL[3]_14 BL[3]_15 BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21
+  BL[3]_22 BL[3]_23 BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29
+  BL[3]_30 BL[3]_31 BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1
+  NBL[0]_2 NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9
+  NBL[0]_10 NBL[0]_11 NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16
+  NBL[0]_17 NBL[0]_18 NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23
+  NBL[0]_24 NBL[0]_25 NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30
+  NBL[0]_31 NBL[0]_32 NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1
+  NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9
+  NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16
+  NBL[1]_17 NBL[1]_18 NBL[1]_19 NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23
+  NBL[1]_24 NBL[1]_25 NBL[1]_26 NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30
+  NBL[1]_31 NBL[1]_32 NBL[1]_33 NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1
+  NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9
+  NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13 NBL[2]_14 NBL[2]_15 NBL[2]_16
+  NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20 NBL[2]_21 NBL[2]_22 NBL[2]_23
+  NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27 NBL[2]_28 NBL[2]_29 NBL[2]_30
+  NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34 NBL[2]_35 NBL[3]_0 NBL[3]_1
+  NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 NBL[3]_8 NBL[3]_9
+  NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13 NBL[3]_14 NBL[3]_15 NBL[3]_16
+  NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20 NBL[3]_21 NBL[3]_22 NBL[3]_23
+  NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27 NBL[3]_28 NBL[3]_29 NBL[3]_30
+  NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34 NBL[3]_35 VDDC VDDPE VDDPE VDDPE
+  VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE
+  VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE
+  VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VPW
+  sram464x144IOTOPCAP_R
.ENDS sram464x144IO_ROW_R
****
.SUBCKT sram464x144IO_SLICE ACTP BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4
+  BL[0]_5 BL[0]_6 BL[0]_7 BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13
+  BL[0]_14 BL[0]_15 BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21
+  BL[0]_22 BL[0]_23 BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29
+  BL[0]_30 BL[0]_31 BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[0]_36 BL[0]_37
+  BL[0]_38 BL[0]_39 BL[0]_40 BL[0]_41 BL[0]_42 BL[0]_43 BL[0]_44 BL[0]_45
+  BL[0]_46 BL[0]_47 BL[0]_48 BL[0]_49 BL[0]_50 BL[0]_51 BL[0]_52 BL[0]_53
+  BL[0]_54 BL[0]_55 BL[0]_56 BL[0]_57 BL[0]_58 BL[0]_59 BL[0]_60 BL[0]_61
+  BL[0]_62 BL[0]_63 BL[0]_64 BL[0]_65 BL[0]_66 BL[0]_67 BL[0]_68 BL[0]_69
+  BL[0]_70 BL[0]_71 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6
+  BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13 BL[1]_14
+  BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21 BL[1]_22
+  BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29 BL[1]_30
+  BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[1]_36 BL[1]_37 BL[1]_38
+  BL[1]_39 BL[1]_40 BL[1]_41 BL[1]_42 BL[1]_43 BL[1]_44 BL[1]_45 BL[1]_46
+  BL[1]_47 BL[1]_48 BL[1]_49 BL[1]_50 BL[1]_51 BL[1]_52 BL[1]_53 BL[1]_54
+  BL[1]_55 BL[1]_56 BL[1]_57 BL[1]_58 BL[1]_59 BL[1]_60 BL[1]_61 BL[1]_62
+  BL[1]_63 BL[1]_64 BL[1]_65 BL[1]_66 BL[1]_67 BL[1]_68 BL[1]_69 BL[1]_70
+  BL[1]_71 BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7
+  BL[2]_8 BL[2]_9 BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15
+  BL[2]_16 BL[2]_17 BL[2]_18 BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23
+  BL[2]_24 BL[2]_25 BL[2]_26 BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31
+  BL[2]_32 BL[2]_33 BL[2]_34 BL[2]_35 BL[2]_36 BL[2]_37 BL[2]_38 BL[2]_39
+  BL[2]_40 BL[2]_41 BL[2]_42 BL[2]_43 BL[2]_44 BL[2]_45 BL[2]_46 BL[2]_47
+  BL[2]_48 BL[2]_49 BL[2]_50 BL[2]_51 BL[2]_52 BL[2]_53 BL[2]_54 BL[2]_55
+  BL[2]_56 BL[2]_57 BL[2]_58 BL[2]_59 BL[2]_60 BL[2]_61 BL[2]_62 BL[2]_63
+  BL[2]_64 BL[2]_65 BL[2]_66 BL[2]_67 BL[2]_68 BL[2]_69 BL[2]_70 BL[2]_71
+  BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 BL[3]_8
+  BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15 BL[3]_16
+  BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23 BL[3]_24
+  BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31 BL[3]_32
+  BL[3]_33 BL[3]_34 BL[3]_35 BL[3]_36 BL[3]_37 BL[3]_38 BL[3]_39 BL[3]_40
+  BL[3]_41 BL[3]_42 BL[3]_43 BL[3]_44 BL[3]_45 BL[3]_46 BL[3]_47 BL[3]_48
+  BL[3]_49 BL[3]_50 BL[3]_51 BL[3]_52 BL[3]_53 BL[3]_54 BL[3]_55 BL[3]_56
+  BL[3]_57 BL[3]_58 BL[3]_59 BL[3]_60 BL[3]_61 BL[3]_62 BL[3]_63 BL[3]_64
+  BL[3]_65 BL[3]_66 BL[3]_67 BL[3]_68 BL[3]_69 BL[3]_70 BL[3]_71 CA0 CA1 CA2
+  CEN CLK D0_0 D0_1 D0_2 D0_3 D0_4 D0_5 D0_6 D0_7 D0_8 D0_9 D0_10 D0_11 D0_12
+  D0_13 D0_14 D0_15 D0_16 D0_17 D0_18 D0_19 D0_20 D0_21 D0_22 D0_23 D0_24
+  D0_25 D0_26 D0_27 D0_28 D0_29 D0_30 D0_31 D0_32 D0_33 D0_34 D0_35 D0_36
+  D0_37 D0_38 D0_39 D0_40 D0_41 D0_42 D0_43 D0_44 D0_45 D0_46 D0_47 D0_48
+  D0_49 D0_50 D0_51 D0_52 D0_53 D0_54 D0_55 D0_56 D0_57 D0_58 D0_59 D0_60
+  D0_61 D0_62 D0_63 D0_64 D0_65 D0_66 D0_67 D0_68 D0_69 D0_70 D0_71 D1_0 D1_1
+  D1_2 D1_3 D1_4 D1_5 D1_6 D1_7 D1_8 D1_9 D1_10 D1_11 D1_12 D1_13 D1_14 D1_15
+  D1_16 D1_17 D1_18 D1_19 D1_20 D1_21 D1_22 D1_23 D1_24 D1_25 D1_26 D1_27
+  D1_28 D1_29 D1_30 D1_31 D1_32 D1_33 D1_34 D1_35 D1_36 D1_37 D1_38 D1_39
+  D1_40 D1_41 D1_42 D1_43 D1_44 D1_45 D1_46 D1_47 D1_48 D1_49 D1_50 D1_51
+  D1_52 D1_53 D1_54 D1_55 D1_56 D1_57 D1_58 D1_59 D1_60 D1_61 D1_62 D1_63
+  D1_64 D1_65 D1_66 D1_67 D1_68 D1_69 D1_70 D1_71 DBL DWL EMAW[0] EMAW[1]
+  EMA[0] EMA[1] EMA[2] GTP GWEN LA0 LA1 LA2 LA_P2[0] LA_P2[1] LA_P2[2] LOG0_0
+  LOG0_1 LOG0_2 LOG0_DWL LOG1 NACTC NACT_CC NBL[0]_0 NBL[0]_1 NBL[0]_2
+  NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10
+  NBL[0]_11 NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17
+  NBL[0]_18 NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24
+  NBL[0]_25 NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31
+  NBL[0]_32 NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[0]_36 NBL[0]_37 NBL[0]_38
+  NBL[0]_39 NBL[0]_40 NBL[0]_41 NBL[0]_42 NBL[0]_43 NBL[0]_44 NBL[0]_45
+  NBL[0]_46 NBL[0]_47 NBL[0]_48 NBL[0]_49 NBL[0]_50 NBL[0]_51 NBL[0]_52
+  NBL[0]_53 NBL[0]_54 NBL[0]_55 NBL[0]_56 NBL[0]_57 NBL[0]_58 NBL[0]_59
+  NBL[0]_60 NBL[0]_61 NBL[0]_62 NBL[0]_63 NBL[0]_64 NBL[0]_65 NBL[0]_66
+  NBL[0]_67 NBL[0]_68 NBL[0]_69 NBL[0]_70 NBL[0]_71 NBL[1]_0 NBL[1]_1
+  NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9
+  NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16
+  NBL[1]_17 NBL[1]_18 NBL[1]_19 NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23
+  NBL[1]_24 NBL[1]_25 NBL[1]_26 NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30
+  NBL[1]_31 NBL[1]_32 NBL[1]_33 NBL[1]_34 NBL[1]_35 NBL[1]_36 NBL[1]_37
+  NBL[1]_38 NBL[1]_39 NBL[1]_40 NBL[1]_41 NBL[1]_42 NBL[1]_43 NBL[1]_44
+  NBL[1]_45 NBL[1]_46 NBL[1]_47 NBL[1]_48 NBL[1]_49 NBL[1]_50 NBL[1]_51
+  NBL[1]_52 NBL[1]_53 NBL[1]_54 NBL[1]_55 NBL[1]_56 NBL[1]_57 NBL[1]_58
+  NBL[1]_59 NBL[1]_60 NBL[1]_61 NBL[1]_62 NBL[1]_63 NBL[1]_64 NBL[1]_65
+  NBL[1]_66 NBL[1]_67 NBL[1]_68 NBL[1]_69 NBL[1]_70 NBL[1]_71 NBL[2]_0
+  NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[2]_8
+  NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13 NBL[2]_14 NBL[2]_15
+  NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20 NBL[2]_21 NBL[2]_22
+  NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27 NBL[2]_28 NBL[2]_29
+  NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34 NBL[2]_35 NBL[2]_36
+  NBL[2]_37 NBL[2]_38 NBL[2]_39 NBL[2]_40 NBL[2]_41 NBL[2]_42 NBL[2]_43
+  NBL[2]_44 NBL[2]_45 NBL[2]_46 NBL[2]_47 NBL[2]_48 NBL[2]_49 NBL[2]_50
+  NBL[2]_51 NBL[2]_52 NBL[2]_53 NBL[2]_54 NBL[2]_55 NBL[2]_56 NBL[2]_57
+  NBL[2]_58 NBL[2]_59 NBL[2]_60 NBL[2]_61 NBL[2]_62 NBL[2]_63 NBL[2]_64
+  NBL[2]_65 NBL[2]_66 NBL[2]_67 NBL[2]_68 NBL[2]_69 NBL[2]_70 NBL[2]_71
+  NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7
+  NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13 NBL[3]_14
+  NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20 NBL[3]_21
+  NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27 NBL[3]_28
+  NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34 NBL[3]_35
+  NBL[3]_36 NBL[3]_37 NBL[3]_38 NBL[3]_39 NBL[3]_40 NBL[3]_41 NBL[3]_42
+  NBL[3]_43 NBL[3]_44 NBL[3]_45 NBL[3]_46 NBL[3]_47 NBL[3]_48 NBL[3]_49
+  NBL[3]_50 NBL[3]_51 NBL[3]_52 NBL[3]_53 NBL[3]_54 NBL[3]_55 NBL[3]_56
+  NBL[3]_57 NBL[3]_58 NBL[3]_59 NBL[3]_60 NBL[3]_61 NBL[3]_62 NBL[3]_63
+  NBL[3]_64 NBL[3]_65 NBL[3]_66 NBL[3]_67 NBL[3]_68 NBL[3]_69 NBL[3]_70
+  NBL[3]_71 NGWE NRETNVT Q0_0 Q0_1 Q0_2 Q0_3 Q0_4 Q0_5 Q0_6 Q0_7 Q0_8 Q0_9
+  Q0_10 Q0_11 Q0_12 Q0_13 Q0_14 Q0_15 Q0_16 Q0_17 Q0_18 Q0_19 Q0_20 Q0_21
+  Q0_22 Q0_23 Q0_24 Q0_25 Q0_26 Q0_27 Q0_28 Q0_29 Q0_30 Q0_31 Q0_32 Q0_33
+  Q0_34 Q0_35 Q0_36 Q0_37 Q0_38 Q0_39 Q0_40 Q0_41 Q0_42 Q0_43 Q0_44 Q0_45
+  Q0_46 Q0_47 Q0_48 Q0_49 Q0_50 Q0_51 Q0_52 Q0_53 Q0_54 Q0_55 Q0_56 Q0_57
+  Q0_58 Q0_59 Q0_60 Q0_61 Q0_62 Q0_63 Q0_64 Q0_65 Q0_66 Q0_67 Q0_68 Q0_69
+  Q0_70 Q0_71 Q1_0 Q1_1 Q1_2 Q1_3 Q1_4 Q1_5 Q1_6 Q1_7 Q1_8 Q1_9 Q1_10 Q1_11
+  Q1_12 Q1_13 Q1_14 Q1_15 Q1_16 Q1_17 Q1_18 Q1_19 Q1_20 Q1_21 Q1_22 Q1_23
+  Q1_24 Q1_25 Q1_26 Q1_27 Q1_28 Q1_29 Q1_30 Q1_31 Q1_32 Q1_33 Q1_34 Q1_35
+  Q1_36 Q1_37 Q1_38 Q1_39 Q1_40 Q1_41 Q1_42 Q1_43 Q1_44 Q1_45 Q1_46 Q1_47
+  Q1_48 Q1_49 Q1_50 Q1_51 Q1_52 Q1_53 Q1_54 Q1_55 Q1_56 Q1_57 Q1_58 Q1_59
+  Q1_60 Q1_61 Q1_62 Q1_63 Q1_64 Q1_65 Q1_66 Q1_67 Q1_68 Q1_69 Q1_70 Q1_71 RA0
+  RA1 RA2 RA3 RA4 RA5 RA_P2[0] RA_P2[1] RA_P2[2] RA_P2[3] RA_P2[4] RET RET1N
+  SAE_DUMMY TD0_0 TD0_1 TD0_2 TD0_3 TD0_4 TD0_5 TD0_6 TD0_7 TD0_8 TD0_9
+  TD0_10 TD0_11 TD0_12 TD0_13 TD0_14 TD0_15 TD0_16 TD0_17 TD0_18 TD0_19
+  TD0_20 TD0_21 TD0_22 TD0_23 TD0_24 TD0_25 TD0_26 TD0_27 TD0_28 TD0_29
+  TD0_30 TD0_31 TD0_32 TD0_33 TD0_34 TD0_35 TD0_36 TD0_37 TD0_38 TD0_39
+  TD0_40 TD0_41 TD0_42 TD0_43 TD0_44 TD0_45 TD0_46 TD0_47 TD0_48 TD0_49
+  TD0_50 TD0_51 TD0_52 TD0_53 TD0_54 TD0_55 TD0_56 TD0_57 TD0_58 TD0_59
+  TD0_60 TD0_61 TD0_62 TD0_63 TD0_64 TD0_65 TD0_66 TD0_67 TD0_68 TD0_69
+  TD0_70 TD0_71 TD1_0 TD1_1 TD1_2 TD1_3 TD1_4 TD1_5 TD1_6 TD1_7 TD1_8 TD1_9
+  TD1_10 TD1_11 TD1_12 TD1_13 TD1_14 TD1_15 TD1_16 TD1_17 TD1_18 TD1_19
+  TD1_20 TD1_21 TD1_22 TD1_23 TD1_24 TD1_25 TD1_26 TD1_27 TD1_28 TD1_29
+  TD1_30 TD1_31 TD1_32 TD1_33 TD1_34 TD1_35 TD1_36 TD1_37 TD1_38 TD1_39
+  TD1_40 TD1_41 TD1_42 TD1_43 TD1_44 TD1_45 TD1_46 TD1_47 TD1_48 TD1_49
+  TD1_50 TD1_51 TD1_52 TD1_53 TD1_54 TD1_55 TD1_56 TD1_57 TD1_58 TD1_59
+  TD1_60 TD1_61 TD1_62 TD1_63 TD1_64 TD1_65 TD1_66 TD1_67 TD1_68 TD1_69
+  TD1_70 TD1_71 TWEN0_0 TWEN0_1 TWEN0_2 TWEN0_3 TWEN0_4 TWEN0_5 TWEN0_6
+  TWEN0_7 TWEN0_8 TWEN0_9 TWEN0_10 TWEN0_11 TWEN0_12 TWEN0_13 TWEN0_14
+  TWEN0_15 TWEN0_16 TWEN0_17 TWEN0_18 TWEN0_19 TWEN0_20 TWEN0_21 TWEN0_22
+  TWEN0_23 TWEN0_24 TWEN0_25 TWEN0_26 TWEN0_27 TWEN0_28 TWEN0_29 TWEN0_30
+  TWEN0_31 TWEN0_32 TWEN0_33 TWEN0_34 TWEN0_35 TWEN0_36 TWEN0_37 TWEN0_38
+  TWEN0_39 TWEN0_40 TWEN0_41 TWEN0_42 TWEN0_43 TWEN0_44 TWEN0_45 TWEN0_46
+  TWEN0_47 TWEN0_48 TWEN0_49 TWEN0_50 TWEN0_51 TWEN0_52 TWEN0_53 TWEN0_54
+  TWEN0_55 TWEN0_56 TWEN0_57 TWEN0_58 TWEN0_59 TWEN0_60 TWEN0_61 TWEN0_62
+  TWEN0_63 TWEN0_64 TWEN0_65 TWEN0_66 TWEN0_67 TWEN0_68 TWEN0_69 TWEN0_70
+  TWEN0_71 TWEN1_0 TWEN1_1 TWEN1_2 TWEN1_3 TWEN1_4 TWEN1_5 TWEN1_6 TWEN1_7
+  TWEN1_8 TWEN1_9 TWEN1_10 TWEN1_11 TWEN1_12 TWEN1_13 TWEN1_14 TWEN1_15
+  TWEN1_16 TWEN1_17 TWEN1_18 TWEN1_19 TWEN1_20 TWEN1_21 TWEN1_22 TWEN1_23
+  TWEN1_24 TWEN1_25 TWEN1_26 TWEN1_27 TWEN1_28 TWEN1_29 TWEN1_30 TWEN1_31
+  TWEN1_32 TWEN1_33 TWEN1_34 TWEN1_35 TWEN1_36 TWEN1_37 TWEN1_38 TWEN1_39
+  TWEN1_40 TWEN1_41 TWEN1_42 TWEN1_43 TWEN1_44 TWEN1_45 TWEN1_46 TWEN1_47
+  TWEN1_48 TWEN1_49 TWEN1_50 TWEN1_51 TWEN1_52 TWEN1_53 TWEN1_54 TWEN1_55
+  TWEN1_56 TWEN1_57 TWEN1_58 TWEN1_59 TWEN1_60 TWEN1_61 TWEN1_62 TWEN1_63
+  TWEN1_64 TWEN1_65 TWEN1_66 TWEN1_67 TWEN1_68 TWEN1_69 TWEN1_70 TWEN1_71
+  VDDC VDDP VDDPE VPW WEN0_0 WEN0_1 WEN0_2 WEN0_3 WEN0_4 WEN0_5 WEN0_6 WEN0_7
+  WEN0_8 WEN0_9 WEN0_10 WEN0_11 WEN0_12 WEN0_13 WEN0_14 WEN0_15 WEN0_16
+  WEN0_17 WEN0_18 WEN0_19 WEN0_20 WEN0_21 WEN0_22 WEN0_23 WEN0_24 WEN0_25
+  WEN0_26 WEN0_27 WEN0_28 WEN0_29 WEN0_30 WEN0_31 WEN0_32 WEN0_33 WEN0_34
+  WEN0_35 WEN0_36 WEN0_37 WEN0_38 WEN0_39 WEN0_40 WEN0_41 WEN0_42 WEN0_43
+  WEN0_44 WEN0_45 WEN0_46 WEN0_47 WEN0_48 WEN0_49 WEN0_50 WEN0_51 WEN0_52
+  WEN0_53 WEN0_54 WEN0_55 WEN0_56 WEN0_57 WEN0_58 WEN0_59 WEN0_60 WEN0_61
+  WEN0_62 WEN0_63 WEN0_64 WEN0_65 WEN0_66 WEN0_67 WEN0_68 WEN0_69 WEN0_70
+  WEN0_71 WEN1_0 WEN1_1 WEN1_2 WEN1_3 WEN1_4 WEN1_5 WEN1_6 WEN1_7 WEN1_8
+  WEN1_9 WEN1_10 WEN1_11 WEN1_12 WEN1_13 WEN1_14 WEN1_15 WEN1_16 WEN1_17
+  WEN1_18 WEN1_19 WEN1_20 WEN1_21 WEN1_22 WEN1_23 WEN1_24 WEN1_25 WEN1_26
+  WEN1_27 WEN1_28 WEN1_29 WEN1_30 WEN1_31 WEN1_32 WEN1_33 WEN1_34 WEN1_35
+  WEN1_36 WEN1_37 WEN1_38 WEN1_39 WEN1_40 WEN1_41 WEN1_42 WEN1_43 WEN1_44
+  WEN1_45 WEN1_46 WEN1_47 WEN1_48 WEN1_49 WEN1_50 WEN1_51 WEN1_52 WEN1_53
+  WEN1_54 WEN1_55 WEN1_56 WEN1_57 WEN1_58 WEN1_59 WEN1_60 WEN1_61 WEN1_62
+  WEN1_63 WEN1_64 WEN1_65 WEN1_66 WEN1_67 WEN1_68 WEN1_69 WEN1_70 WEN1_71
+  WENY0_0 WENY0_1 WENY0_2 WENY0_3 WENY0_4 WENY0_5 WENY0_6 WENY0_7 WENY0_8
+  WENY0_9 WENY0_10 WENY0_11 WENY0_12 WENY0_13 WENY0_14 WENY0_15 WENY0_16
+  WENY0_17 WENY0_18 WENY0_19 WENY0_20 WENY0_21 WENY0_22 WENY0_23 WENY0_24
+  WENY0_25 WENY0_26 WENY0_27 WENY0_28 WENY0_29 WENY0_30 WENY0_31 WENY0_32
+  WENY0_33 WENY0_34 WENY0_35 WENY0_36 WENY0_37 WENY0_38 WENY0_39 WENY0_40
+  WENY0_41 WENY0_42 WENY0_43 WENY0_44 WENY0_45 WENY0_46 WENY0_47 WENY0_48
+  WENY0_49 WENY0_50 WENY0_51 WENY0_52 WENY0_53 WENY0_54 WENY0_55 WENY0_56
+  WENY0_57 WENY0_58 WENY0_59 WENY0_60 WENY0_61 WENY0_62 WENY0_63 WENY0_64
+  WENY0_65 WENY0_66 WENY0_67 WENY0_68 WENY0_69 WENY0_70 WENY0_71 WENY1_0
+  WENY1_1 WENY1_2 WENY1_3 WENY1_4 WENY1_5 WENY1_6 WENY1_7 WENY1_8 WENY1_9
+  WENY1_10 WENY1_11 WENY1_12 WENY1_13 WENY1_14 WENY1_15 WENY1_16 WENY1_17
+  WENY1_18 WENY1_19 WENY1_20 WENY1_21 WENY1_22 WENY1_23 WENY1_24 WENY1_25
+  WENY1_26 WENY1_27 WENY1_28 WENY1_29 WENY1_30 WENY1_31 WENY1_32 WENY1_33
+  WENY1_34 WENY1_35 WENY1_36 WENY1_37 WENY1_38 WENY1_39 WENY1_40 WENY1_41
+  WENY1_42 WENY1_43 WENY1_44 WENY1_45 WENY1_46 WENY1_47 WENY1_48 WENY1_49
+  WENY1_50 WENY1_51 WENY1_52 WENY1_53 WENY1_54 WENY1_55 WENY1_56 WENY1_57
+  WENY1_58 WENY1_59 WENY1_60 WENY1_61 WENY1_62 WENY1_63 WENY1_64 WENY1_65
+  WENY1_66 WENY1_67 WENY1_68 WENY1_69 WENY1_70 WENY1_71
** sram464x144IO_SLICE: 12669 flat devices **
XCK_BLK ACTP BLPRECH BLPRECH_R CA0 CA1 CA2 CEN CLK DBL DUM_SEL_D_R
+  DUM_SEL_D_R_11 DUM_SEL_TD_R DUM_SEL_TD_R_13 DWL EMAW[0] EMAW[1] EMA[0]
+  EMA[1] EMA[2] GTP GWEN LA0 LA1 LA2 LA_P2[0] LA_P2[1] LA_P2[2] LOG0_0
+  LOG0_DWL LOG1 NACTC NACT_CC NGWE NRETNVT NSAE NWCLK NYR0 NYR1 RA0 RA1 RA2
+  RA3 RA4 RA5 RA_P2[0] RA_P2[1] RA_P2[2] RA_P2[3] RA_P2[4] RET RET1N
+  SAE_DUMMY SAPRECH VDDC VDDC VDDC VDDP VDDPE VPW YW0 YW1 sram464x144CNTRL
XIO_LEFT BLPRECH BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6
+  BL[0]_7 BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14
+  BL[0]_15 BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22
+  BL[0]_23 BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30
+  BL[0]_31 BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2
+  BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11
+  BL[1]_12 BL[1]_13 BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19
+  BL[1]_20 BL[1]_21 BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27
+  BL[1]_28 BL[1]_29 BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35
+  BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8
+  BL[2]_9 BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16
+  BL[2]_17 BL[2]_18 BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24
+  BL[2]_25 BL[2]_26 BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32
+  BL[2]_33 BL[2]_34 BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5
+  BL[3]_6 BL[3]_7 BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13
+  BL[3]_14 BL[3]_15 BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21
+  BL[3]_22 BL[3]_23 BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29
+  BL[3]_30 BL[3]_31 BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 D0_0 D0_1 D0_2 D0_3
+  D0_4 D0_5 D0_6 D0_7 D0_8 D0_9 D0_10 D0_11 D0_12 D0_13 D0_14 D0_15 D0_16
+  D0_17 D0_18 D0_19 D0_20 D0_21 D0_22 D0_23 D0_24 D0_25 D0_26 D0_27 D0_28
+  D0_29 D0_30 D0_31 D0_32 D0_33 D0_34 D0_35 D1_0 D1_1 D1_2 D1_3 D1_4 D1_5
+  D1_6 D1_7 D1_8 D1_9 D1_10 D1_11 D1_12 D1_13 D1_14 D1_15 D1_16 D1_17 D1_18
+  D1_19 D1_20 D1_21 D1_22 D1_23 D1_24 D1_25 D1_26 D1_27 D1_28 D1_29 D1_30
+  D1_31 D1_32 D1_33 D1_34 D1_35 DUM_SEL_D_R DUM_SEL_TD_R LOG0_0 LOG0_1 LOG0_0
+  NACT_CC NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6
+  NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11 NBL[0]_12 NBL[0]_13
+  NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18 NBL[0]_19 NBL[0]_20
+  NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25 NBL[0]_26 NBL[0]_27
+  NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32 NBL[0]_33 NBL[0]_34
+  NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6
+  NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13
+  NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19 NBL[1]_20
+  NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26 NBL[1]_27
+  NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33 NBL[1]_34
+  NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6
+  NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 NSAE NWCLK NYR0 NYR1 Q0_0 Q0_1 Q0_2 Q0_3 Q0_4 Q0_5 Q0_6 Q0_7 Q0_8
+  Q0_9 Q0_10 Q0_11 Q0_12 Q0_13 Q0_14 Q0_15 Q0_16 Q0_17 Q0_18 Q0_19 Q0_20
+  Q0_21 Q0_22 Q0_23 Q0_24 Q0_25 Q0_26 Q0_27 Q0_28 Q0_29 Q0_30 Q0_31 Q0_32
+  Q0_33 Q0_34 Q0_35 Q1_0 Q1_1 Q1_2 Q1_3 Q1_4 Q1_5 Q1_6 Q1_7 Q1_8 Q1_9 Q1_10
+  Q1_11 Q1_12 Q1_13 Q1_14 Q1_15 Q1_16 Q1_17 Q1_18 Q1_19 Q1_20 Q1_21 Q1_22
+  Q1_23 Q1_24 Q1_25 Q1_26 Q1_27 Q1_28 Q1_29 Q1_30 Q1_31 Q1_32 Q1_33 Q1_34
+  Q1_35 SAPRECH TD0_0 TD0_1 TD0_2 TD0_3 TD0_4 TD0_5 TD0_6 TD0_7 TD0_8 TD0_9
+  TD0_10 TD0_11 TD0_12 TD0_13 TD0_14 TD0_15 TD0_16 TD0_17 TD0_18 TD0_19
+  TD0_20 TD0_21 TD0_22 TD0_23 TD0_24 TD0_25 TD0_26 TD0_27 TD0_28 TD0_29
+  TD0_30 TD0_31 TD0_32 TD0_33 TD0_34 TD0_35 TD1_0 TD1_1 TD1_2 TD1_3 TD1_4
+  TD1_5 TD1_6 TD1_7 TD1_8 TD1_9 TD1_10 TD1_11 TD1_12 TD1_13 TD1_14 TD1_15
+  TD1_16 TD1_17 TD1_18 TD1_19 TD1_20 TD1_21 TD1_22 TD1_23 TD1_24 TD1_25
+  TD1_26 TD1_27 TD1_28 TD1_29 TD1_30 TD1_31 TD1_32 TD1_33 TD1_34 TD1_35
+  TWEN0_0 TWEN0_1 TWEN0_2 TWEN0_3 TWEN0_4 TWEN0_5 TWEN0_6 TWEN0_7 TWEN0_8
+  TWEN0_9 TWEN0_10 TWEN0_11 TWEN0_12 TWEN0_13 TWEN0_14 TWEN0_15 TWEN0_16
+  TWEN0_17 TWEN0_18 TWEN0_19 TWEN0_20 TWEN0_21 TWEN0_22 TWEN0_23 TWEN0_24
+  TWEN0_25 TWEN0_26 TWEN0_27 TWEN0_28 TWEN0_29 TWEN0_30 TWEN0_31 TWEN0_32
+  TWEN0_33 TWEN0_34 TWEN0_35 TWEN1_0 TWEN1_1 TWEN1_2 TWEN1_3 TWEN1_4 TWEN1_5
+  TWEN1_6 TWEN1_7 TWEN1_8 TWEN1_9 TWEN1_10 TWEN1_11 TWEN1_12 TWEN1_13
+  TWEN1_14 TWEN1_15 TWEN1_16 TWEN1_17 TWEN1_18 TWEN1_19 TWEN1_20 TWEN1_21
+  TWEN1_22 TWEN1_23 TWEN1_24 TWEN1_25 TWEN1_26 TWEN1_27 TWEN1_28 TWEN1_29
+  TWEN1_30 TWEN1_31 TWEN1_32 TWEN1_33 TWEN1_34 TWEN1_35 VDDC VDDPE VPW WEN0_0
+  WEN0_1 WEN0_2 WEN0_3 WEN0_4 WEN0_5 WEN0_6 WEN0_7 WEN0_8 WEN0_9 WEN0_10
+  WEN0_11 WEN0_12 WEN0_13 WEN0_14 WEN0_15 WEN0_16 WEN0_17 WEN0_18 WEN0_19
+  WEN0_20 WEN0_21 WEN0_22 WEN0_23 WEN0_24 WEN0_25 WEN0_26 WEN0_27 WEN0_28
+  WEN0_29 WEN0_30 WEN0_31 WEN0_32 WEN0_33 WEN0_34 WEN0_35 WEN1_0 WEN1_1
+  WEN1_2 WEN1_3 WEN1_4 WEN1_5 WEN1_6 WEN1_7 WEN1_8 WEN1_9 WEN1_10 WEN1_11
+  WEN1_12 WEN1_13 WEN1_14 WEN1_15 WEN1_16 WEN1_17 WEN1_18 WEN1_19 WEN1_20
+  WEN1_21 WEN1_22 WEN1_23 WEN1_24 WEN1_25 WEN1_26 WEN1_27 WEN1_28 WEN1_29
+  WEN1_30 WEN1_31 WEN1_32 WEN1_33 WEN1_34 WEN1_35 WENY0_0 WENY0_1 WENY0_2
+  WENY0_3 WENY0_4 WENY0_5 WENY0_6 WENY0_7 WENY0_8 WENY0_9 WENY0_10 WENY0_11
+  WENY0_12 WENY0_13 WENY0_14 WENY0_15 WENY0_16 WENY0_17 WENY0_18 WENY0_19
+  WENY0_20 WENY0_21 WENY0_22 WENY0_23 WENY0_24 WENY0_25 WENY0_26 WENY0_27
+  WENY0_28 WENY0_29 WENY0_30 WENY0_31 WENY0_32 WENY0_33 WENY0_34 WENY0_35
+  WENY1_0 WENY1_1 WENY1_2 WENY1_3 WENY1_4 WENY1_5 WENY1_6 WENY1_7 WENY1_8
+  WENY1_9 WENY1_10 WENY1_11 WENY1_12 WENY1_13 WENY1_14 WENY1_15 WENY1_16
+  WENY1_17 WENY1_18 WENY1_19 WENY1_20 WENY1_21 WENY1_22 WENY1_23 WENY1_24
+  WENY1_25 WENY1_26 WENY1_27 WENY1_28 WENY1_29 WENY1_30 WENY1_31 WENY1_32
+  WENY1_33 WENY1_34 WENY1_35 YW0 YW1 sram464x144IO_ROW_L
XIO_RIGHT BLPRECH_R BL[0]_36 BL[0]_37 BL[0]_38 BL[0]_39 BL[0]_40 BL[0]_41
+  BL[0]_42 BL[0]_43 BL[0]_44 BL[0]_45 BL[0]_46 BL[0]_47 BL[0]_48 BL[0]_49
+  BL[0]_50 BL[0]_51 BL[0]_52 BL[0]_53 BL[0]_54 BL[0]_55 BL[0]_56 BL[0]_57
+  BL[0]_58 BL[0]_59 BL[0]_60 BL[0]_61 BL[0]_62 BL[0]_63 BL[0]_64 BL[0]_65
+  BL[0]_66 BL[0]_67 BL[0]_68 BL[0]_69 BL[0]_70 BL[0]_71 BL[1]_36 BL[1]_37
+  BL[1]_38 BL[1]_39 BL[1]_40 BL[1]_41 BL[1]_42 BL[1]_43 BL[1]_44 BL[1]_45
+  BL[1]_46 BL[1]_47 BL[1]_48 BL[1]_49 BL[1]_50 BL[1]_51 BL[1]_52 BL[1]_53
+  BL[1]_54 BL[1]_55 BL[1]_56 BL[1]_57 BL[1]_58 BL[1]_59 BL[1]_60 BL[1]_61
+  BL[1]_62 BL[1]_63 BL[1]_64 BL[1]_65 BL[1]_66 BL[1]_67 BL[1]_68 BL[1]_69
+  BL[1]_70 BL[1]_71 BL[2]_36 BL[2]_37 BL[2]_38 BL[2]_39 BL[2]_40 BL[2]_41
+  BL[2]_42 BL[2]_43 BL[2]_44 BL[2]_45 BL[2]_46 BL[2]_47 BL[2]_48 BL[2]_49
+  BL[2]_50 BL[2]_51 BL[2]_52 BL[2]_53 BL[2]_54 BL[2]_55 BL[2]_56 BL[2]_57
+  BL[2]_58 BL[2]_59 BL[2]_60 BL[2]_61 BL[2]_62 BL[2]_63 BL[2]_64 BL[2]_65
+  BL[2]_66 BL[2]_67 BL[2]_68 BL[2]_69 BL[2]_70 BL[2]_71 BL[3]_36 BL[3]_37
+  BL[3]_38 BL[3]_39 BL[3]_40 BL[3]_41 BL[3]_42 BL[3]_43 BL[3]_44 BL[3]_45
+  BL[3]_46 BL[3]_47 BL[3]_48 BL[3]_49 BL[3]_50 BL[3]_51 BL[3]_52 BL[3]_53
+  BL[3]_54 BL[3]_55 BL[3]_56 BL[3]_57 BL[3]_58 BL[3]_59 BL[3]_60 BL[3]_61
+  BL[3]_62 BL[3]_63 BL[3]_64 BL[3]_65 BL[3]_66 BL[3]_67 BL[3]_68 BL[3]_69
+  BL[3]_70 BL[3]_71 D0_36 D0_37 D0_38 D0_39 D0_40 D0_41 D0_42 D0_43 D0_44
+  D0_45 D0_46 D0_47 D0_48 D0_49 D0_50 D0_51 D0_52 D0_53 D0_54 D0_55 D0_56
+  D0_57 D0_58 D0_59 D0_60 D0_61 D0_62 D0_63 D0_64 D0_65 D0_66 D0_67 D0_68
+  D0_69 D0_70 D0_71 D1_36 D1_37 D1_38 D1_39 D1_40 D1_41 D1_42 D1_43 D1_44
+  D1_45 D1_46 D1_47 D1_48 D1_49 D1_50 D1_51 D1_52 D1_53 D1_54 D1_55 D1_56
+  D1_57 D1_58 D1_59 D1_60 D1_61 D1_62 D1_63 D1_64 D1_65 D1_66 D1_67 D1_68
+  D1_69 D1_70 D1_71 DUM_SEL_D_R_11 DUM_SEL_TD_R_13 DWL LOG0_2 LOG0_0 NACT_CC
+  NBL[0]_36 NBL[0]_37 NBL[0]_38 NBL[0]_39 NBL[0]_40 NBL[0]_41 NBL[0]_42
+  NBL[0]_43 NBL[0]_44 NBL[0]_45 NBL[0]_46 NBL[0]_47 NBL[0]_48 NBL[0]_49
+  NBL[0]_50 NBL[0]_51 NBL[0]_52 NBL[0]_53 NBL[0]_54 NBL[0]_55 NBL[0]_56
+  NBL[0]_57 NBL[0]_58 NBL[0]_59 NBL[0]_60 NBL[0]_61 NBL[0]_62 NBL[0]_63
+  NBL[0]_64 NBL[0]_65 NBL[0]_66 NBL[0]_67 NBL[0]_68 NBL[0]_69 NBL[0]_70
+  NBL[0]_71 NBL[1]_36 NBL[1]_37 NBL[1]_38 NBL[1]_39 NBL[1]_40 NBL[1]_41
+  NBL[1]_42 NBL[1]_43 NBL[1]_44 NBL[1]_45 NBL[1]_46 NBL[1]_47 NBL[1]_48
+  NBL[1]_49 NBL[1]_50 NBL[1]_51 NBL[1]_52 NBL[1]_53 NBL[1]_54 NBL[1]_55
+  NBL[1]_56 NBL[1]_57 NBL[1]_58 NBL[1]_59 NBL[1]_60 NBL[1]_61 NBL[1]_62
+  NBL[1]_63 NBL[1]_64 NBL[1]_65 NBL[1]_66 NBL[1]_67 NBL[1]_68 NBL[1]_69
+  NBL[1]_70 NBL[1]_71 NBL[2]_36 NBL[2]_37 NBL[2]_38 NBL[2]_39 NBL[2]_40
+  NBL[2]_41 NBL[2]_42 NBL[2]_43 NBL[2]_44 NBL[2]_45 NBL[2]_46 NBL[2]_47
+  NBL[2]_48 NBL[2]_49 NBL[2]_50 NBL[2]_51 NBL[2]_52 NBL[2]_53 NBL[2]_54
+  NBL[2]_55 NBL[2]_56 NBL[2]_57 NBL[2]_58 NBL[2]_59 NBL[2]_60 NBL[2]_61
+  NBL[2]_62 NBL[2]_63 NBL[2]_64 NBL[2]_65 NBL[2]_66 NBL[2]_67 NBL[2]_68
+  NBL[2]_69 NBL[2]_70 NBL[2]_71 NBL[3]_36 NBL[3]_37 NBL[3]_38 NBL[3]_39
+  NBL[3]_40 NBL[3]_41 NBL[3]_42 NBL[3]_43 NBL[3]_44 NBL[3]_45 NBL[3]_46
+  NBL[3]_47 NBL[3]_48 NBL[3]_49 NBL[3]_50 NBL[3]_51 NBL[3]_52 NBL[3]_53
+  NBL[3]_54 NBL[3]_55 NBL[3]_56 NBL[3]_57 NBL[3]_58 NBL[3]_59 NBL[3]_60
+  NBL[3]_61 NBL[3]_62 NBL[3]_63 NBL[3]_64 NBL[3]_65 NBL[3]_66 NBL[3]_67
+  NBL[3]_68 NBL[3]_69 NBL[3]_70 NBL[3]_71 NSAE NWCLK NYR0 NYR1 Q0_36 Q0_37
+  Q0_38 Q0_39 Q0_40 Q0_41 Q0_42 Q0_43 Q0_44 Q0_45 Q0_46 Q0_47 Q0_48 Q0_49
+  Q0_50 Q0_51 Q0_52 Q0_53 Q0_54 Q0_55 Q0_56 Q0_57 Q0_58 Q0_59 Q0_60 Q0_61
+  Q0_62 Q0_63 Q0_64 Q0_65 Q0_66 Q0_67 Q0_68 Q0_69 Q0_70 Q0_71 Q1_36 Q1_37
+  Q1_38 Q1_39 Q1_40 Q1_41 Q1_42 Q1_43 Q1_44 Q1_45 Q1_46 Q1_47 Q1_48 Q1_49
+  Q1_50 Q1_51 Q1_52 Q1_53 Q1_54 Q1_55 Q1_56 Q1_57 Q1_58 Q1_59 Q1_60 Q1_61
+  Q1_62 Q1_63 Q1_64 Q1_65 Q1_66 Q1_67 Q1_68 Q1_69 Q1_70 Q1_71 SAPRECH TD0_36
+  TD0_37 TD0_38 TD0_39 TD0_40 TD0_41 TD0_42 TD0_43 TD0_44 TD0_45 TD0_46
+  TD0_47 TD0_48 TD0_49 TD0_50 TD0_51 TD0_52 TD0_53 TD0_54 TD0_55 TD0_56
+  TD0_57 TD0_58 TD0_59 TD0_60 TD0_61 TD0_62 TD0_63 TD0_64 TD0_65 TD0_66
+  TD0_67 TD0_68 TD0_69 TD0_70 TD0_71 TD1_36 TD1_37 TD1_38 TD1_39 TD1_40
+  TD1_41 TD1_42 TD1_43 TD1_44 TD1_45 TD1_46 TD1_47 TD1_48 TD1_49 TD1_50
+  TD1_51 TD1_52 TD1_53 TD1_54 TD1_55 TD1_56 TD1_57 TD1_58 TD1_59 TD1_60
+  TD1_61 TD1_62 TD1_63 TD1_64 TD1_65 TD1_66 TD1_67 TD1_68 TD1_69 TD1_70
+  TD1_71 TWEN0_36 TWEN0_37 TWEN0_38 TWEN0_39 TWEN0_40 TWEN0_41 TWEN0_42
+  TWEN0_43 TWEN0_44 TWEN0_45 TWEN0_46 TWEN0_47 TWEN0_48 TWEN0_49 TWEN0_50
+  TWEN0_51 TWEN0_52 TWEN0_53 TWEN0_54 TWEN0_55 TWEN0_56 TWEN0_57 TWEN0_58
+  TWEN0_59 TWEN0_60 TWEN0_61 TWEN0_62 TWEN0_63 TWEN0_64 TWEN0_65 TWEN0_66
+  TWEN0_67 TWEN0_68 TWEN0_69 TWEN0_70 TWEN0_71 TWEN1_36 TWEN1_37 TWEN1_38
+  TWEN1_39 TWEN1_40 TWEN1_41 TWEN1_42 TWEN1_43 TWEN1_44 TWEN1_45 TWEN1_46
+  TWEN1_47 TWEN1_48 TWEN1_49 TWEN1_50 TWEN1_51 TWEN1_52 TWEN1_53 TWEN1_54
+  TWEN1_55 TWEN1_56 TWEN1_57 TWEN1_58 TWEN1_59 TWEN1_60 TWEN1_61 TWEN1_62
+  TWEN1_63 TWEN1_64 TWEN1_65 TWEN1_66 TWEN1_67 TWEN1_68 TWEN1_69 TWEN1_70
+  TWEN1_71 VDDC VDDPE VPW WEN0_36 WEN0_37 WEN0_38 WEN0_39 WEN0_40 WEN0_41
+  WEN0_42 WEN0_43 WEN0_44 WEN0_45 WEN0_46 WEN0_47 WEN0_48 WEN0_49 WEN0_50
+  WEN0_51 WEN0_52 WEN0_53 WEN0_54 WEN0_55 WEN0_56 WEN0_57 WEN0_58 WEN0_59
+  WEN0_60 WEN0_61 WEN0_62 WEN0_63 WEN0_64 WEN0_65 WEN0_66 WEN0_67 WEN0_68
+  WEN0_69 WEN0_70 WEN0_71 WEN1_36 WEN1_37 WEN1_38 WEN1_39 WEN1_40 WEN1_41
+  WEN1_42 WEN1_43 WEN1_44 WEN1_45 WEN1_46 WEN1_47 WEN1_48 WEN1_49 WEN1_50
+  WEN1_51 WEN1_52 WEN1_53 WEN1_54 WEN1_55 WEN1_56 WEN1_57 WEN1_58 WEN1_59
+  WEN1_60 WEN1_61 WEN1_62 WEN1_63 WEN1_64 WEN1_65 WEN1_66 WEN1_67 WEN1_68
+  WEN1_69 WEN1_70 WEN1_71 WENY0_36 WENY0_37 WENY0_38 WENY0_39 WENY0_40
+  WENY0_41 WENY0_42 WENY0_43 WENY0_44 WENY0_45 WENY0_46 WENY0_47 WENY0_48
+  WENY0_49 WENY0_50 WENY0_51 WENY0_52 WENY0_53 WENY0_54 WENY0_55 WENY0_56
+  WENY0_57 WENY0_58 WENY0_59 WENY0_60 WENY0_61 WENY0_62 WENY0_63 WENY0_64
+  WENY0_65 WENY0_66 WENY0_67 WENY0_68 WENY0_69 WENY0_70 WENY0_71 WENY1_36
+  WENY1_37 WENY1_38 WENY1_39 WENY1_40 WENY1_41 WENY1_42 WENY1_43 WENY1_44
+  WENY1_45 WENY1_46 WENY1_47 WENY1_48 WENY1_49 WENY1_50 WENY1_51 WENY1_52
+  WENY1_53 WENY1_54 WENY1_55 WENY1_56 WENY1_57 WENY1_58 WENY1_59 WENY1_60
+  WENY1_61 WENY1_62 WENY1_63 WENY1_64 WENY1_65 WENY1_66 WENY1_67 WENY1_68
+  WENY1_69 WENY1_70 WENY1_71 YW0 YW1 sram464x144IO_ROW_R
.ENDS sram464x144IO_SLICE
****
.SUBCKT sram464x144CCHD4_EDG VNWC VNWP VPW VSSE WL[0] WL[1]
** sram464x144CCHD4_EDG: 2 flat devices **
X_MXN0 VSSE NET14 VSSE VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MXN1 VSSE NET18 VSSE VPW dslnfetpd_ckt W=0.142U L=0.055U
.ENDS sram464x144CCHD4_EDG
****
.SUBCKT sram464x144CCHD4 BL[0] BL[1] BL[2] BL[3] CORED00 CORED01 CORED10
+  CORED11 CORED20 CORED21 CORED30 CORED31 NBL[0] NBL[1] NBL[2] NBL[3]
+  NCORED00 NCORED01 NCORED10 NCORED11 NCORED20 NCORED21 NCORED30 NCORED31
+  VDDC VDDCE VDDPE VNWC VPW VSSE WL[0] WL[1]
** sram464x144CCHD4: 48 flat devices **
X_MI17._cell.MXN0 NCORED30 CORED30 VSSE VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MI17._cell.MXN1 NBL[3] WL[0] NCORED30 VPW dslnfetwl_ckt W=0.11U L=0.059U
X_MI17._cell.MXN2 BL[3] WL[0] CORED30 VPW dslnfetwl_ckt W=0.11U L=0.059U
X_MI17._cell.MXN3 CORED30 NCORED30 VSSE VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MI17._cell.MXP0 NCORED30 CORED30 VDDC VNWC dslpfetpu_ckt W=0.06U L=0.055U
X_MI17._cell.MXP1 CORED30 NCORED30 VDDC VNWC dslpfetpu_ckt W=0.06U L=0.055U
X_MI18._cell.MXN0 NCORED20 CORED20 VSSE VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MI18._cell.MXN1 NBL[2] WL[0] NCORED20 VPW dslnfetwl_ckt W=0.11U L=0.059U
X_MI18._cell.MXN2 BL[2] WL[0] CORED20 VPW dslnfetwl_ckt W=0.11U L=0.059U
X_MI18._cell.MXN3 CORED20 NCORED20 VSSE VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MI18._cell.MXP0 NCORED20 CORED20 VDDC VNWC dslpfetpu_ckt W=0.06U L=0.055U
X_MI18._cell.MXP1 CORED20 NCORED20 VDDC VNWC dslpfetpu_ckt W=0.06U L=0.055U
X_MI19._cell.MXN0 NCORED10 CORED10 VSSE VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MI19._cell.MXN1 NBL[1] WL[0] NCORED10 VPW dslnfetwl_ckt W=0.11U L=0.059U
X_MI19._cell.MXN2 BL[1] WL[0] CORED10 VPW dslnfetwl_ckt W=0.11U L=0.059U
X_MI19._cell.MXN3 CORED10 NCORED10 VSSE VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MI19._cell.MXP0 NCORED10 CORED10 VDDC VNWC dslpfetpu_ckt W=0.06U L=0.055U
X_MI19._cell.MXP1 CORED10 NCORED10 VDDC VNWC dslpfetpu_ckt W=0.06U L=0.055U
X_MI20._cell.MXN0 NCORED00 CORED00 VSSE VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MI20._cell.MXN1 NBL[0] WL[0] NCORED00 VPW dslnfetwl_ckt W=0.11U L=0.059U
X_MI20._cell.MXN2 BL[0] WL[0] CORED00 VPW dslnfetwl_ckt W=0.11U L=0.059U
X_MI20._cell.MXN3 CORED00 NCORED00 VSSE VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MI20._cell.MXP0 NCORED00 CORED00 VDDC VNWC dslpfetpu_ckt W=0.06U L=0.055U
X_MI20._cell.MXP1 CORED00 NCORED00 VDDC VNWC dslpfetpu_ckt W=0.06U L=0.055U
X_M_cell01._cell.MXN0 NCORED01 CORED01 VSSE VPW dslnfetpd_ckt W=0.142U
+  L=0.055U
X_M_cell01._cell.MXN1 NBL[0] WL[1] NCORED01 VPW dslnfetwl_ckt W=0.11U L=0.059U
X_M_cell01._cell.MXN2 BL[0] WL[1] CORED01 VPW dslnfetwl_ckt W=0.11U L=0.059U
X_M_cell01._cell.MXN3 CORED01 NCORED01 VSSE VPW dslnfetpd_ckt W=0.142U
+  L=0.055U
X_M_cell01._cell.MXP0 NCORED01 CORED01 VDDC VNWC dslpfetpu_ckt W=0.06U
+  L=0.055U
X_M_cell01._cell.MXP1 CORED01 NCORED01 VDDC VNWC dslpfetpu_ckt W=0.06U
+  L=0.055U
X_M_cell11._cell.MXN0 NCORED11 CORED11 VSSE VPW dslnfetpd_ckt W=0.142U
+  L=0.055U
X_M_cell11._cell.MXN1 NBL[1] WL[1] NCORED11 VPW dslnfetwl_ckt W=0.11U L=0.059U
X_M_cell11._cell.MXN2 BL[1] WL[1] CORED11 VPW dslnfetwl_ckt W=0.11U L=0.059U
X_M_cell11._cell.MXN3 CORED11 NCORED11 VSSE VPW dslnfetpd_ckt W=0.142U
+  L=0.055U
X_M_cell11._cell.MXP0 NCORED11 CORED11 VDDC VNWC dslpfetpu_ckt W=0.06U
+  L=0.055U
X_M_cell11._cell.MXP1 CORED11 NCORED11 VDDC VNWC dslpfetpu_ckt W=0.06U
+  L=0.055U
X_M_cell21._cell.MXN0 NCORED21 CORED21 VSSE VPW dslnfetpd_ckt W=0.142U
+  L=0.055U
X_M_cell21._cell.MXN1 NBL[2] WL[1] NCORED21 VPW dslnfetwl_ckt W=0.11U L=0.059U
X_M_cell21._cell.MXN2 BL[2] WL[1] CORED21 VPW dslnfetwl_ckt W=0.11U L=0.059U
X_M_cell21._cell.MXN3 CORED21 NCORED21 VSSE VPW dslnfetpd_ckt W=0.142U
+  L=0.055U
X_M_cell21._cell.MXP0 NCORED21 CORED21 VDDC VNWC dslpfetpu_ckt W=0.06U
+  L=0.055U
X_M_cell21._cell.MXP1 CORED21 NCORED21 VDDC VNWC dslpfetpu_ckt W=0.06U
+  L=0.055U
X_M_cell31._cell.MXN0 NCORED31 CORED31 VSSE VPW dslnfetpd_ckt W=0.142U
+  L=0.055U
X_M_cell31._cell.MXN1 NBL[3] WL[1] NCORED31 VPW dslnfetwl_ckt W=0.11U L=0.059U
X_M_cell31._cell.MXN2 BL[3] WL[1] CORED31 VPW dslnfetwl_ckt W=0.11U L=0.059U
X_M_cell31._cell.MXN3 CORED31 NCORED31 VSSE VPW dslnfetpd_ckt W=0.142U
+  L=0.055U
X_M_cell31._cell.MXP0 NCORED31 CORED31 VDDC VNWC dslpfetpu_ckt W=0.06U
+  L=0.055U
X_M_cell31._cell.MXP1 CORED31 NCORED31 VDDC VNWC dslpfetpu_ckt W=0.06U
+  L=0.055U
.ENDS sram464x144CCHD4
****
.SUBCKT sram464x144CCHD4WD_EDG VNWC VNWP VPW VSSE WL[0] WL[1]
** sram464x144CCHD4WD_EDG: 2 flat devices **
X_MXN0 VSSE NET14 VSSE VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MXN1 VSSE NET18 VSSE VPW dslnfetpd_ckt W=0.142U L=0.055U
.ENDS sram464x144CCHD4WD_EDG
****
.SUBCKT sram464x144MEM_L_ROW BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5
+  BL[0]_6 BL[0]_7 BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13
+  BL[0]_14 BL[0]_15 BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21
+  BL[0]_22 BL[0]_23 BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29
+  BL[0]_30 BL[0]_31 BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1
+  BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10
+  BL[1]_11 BL[1]_12 BL[1]_13 BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18
+  BL[1]_19 BL[1]_20 BL[1]_21 BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26
+  BL[1]_27 BL[1]_28 BL[1]_29 BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34
+  BL[1]_35 BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7
+  BL[2]_8 BL[2]_9 BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15
+  BL[2]_16 BL[2]_17 BL[2]_18 BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23
+  BL[2]_24 BL[2]_25 BL[2]_26 BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31
+  BL[2]_32 BL[2]_33 BL[2]_34 BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4
+  BL[3]_5 BL[3]_6 BL[3]_7 BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13
+  BL[3]_14 BL[3]_15 BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21
+  BL[3]_22 BL[3]_23 BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29
+  BL[3]_30 BL[3]_31 BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1
+  NBL[0]_2 NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9
+  NBL[0]_10 NBL[0]_11 NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16
+  NBL[0]_17 NBL[0]_18 NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23
+  NBL[0]_24 NBL[0]_25 NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30
+  NBL[0]_31 NBL[0]_32 NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1
+  NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9
+  NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16
+  NBL[1]_17 NBL[1]_18 NBL[1]_19 NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23
+  NBL[1]_24 NBL[1]_25 NBL[1]_26 NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30
+  NBL[1]_31 NBL[1]_32 NBL[1]_33 NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1
+  NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9
+  NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13 NBL[2]_14 NBL[2]_15 NBL[2]_16
+  NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20 NBL[2]_21 NBL[2]_22 NBL[2]_23
+  NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27 NBL[2]_28 NBL[2]_29 NBL[2]_30
+  NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34 NBL[2]_35 NBL[3]_0 NBL[3]_1
+  NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 NBL[3]_8 NBL[3]_9
+  NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13 NBL[3]_14 NBL[3]_15 NBL[3]_16
+  NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20 NBL[3]_21 NBL[3]_22 NBL[3]_23
+  NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27 NBL[3]_28 NBL[3]_29 NBL[3]_30
+  NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34 NBL[3]_35 VDDCE_0 VDDCE_1 VDDCE_2
+  VDDCE_3 VDDCE_4 VDDCE_5 VDDCE_6 VDDCE_7 VDDCE_8 VDDCE_9 VDDCE_10 VDDCE_11
+  VDDCE_12 VDDCE_13 VDDCE_14 VDDCE_15 VDDCE_16 VDDCE_17 VDDCE_18 VDDCE_19
+  VDDCE_20 VDDCE_21 VDDCE_22 VDDCE_23 VDDCE_24 VDDCE_25 VDDCE_26 VDDCE_27
+  VDDCE_28 VDDCE_29 VDDCE_30 VDDCE_31 VDDCE_32 VDDCE_33 VDDCE_34 VDDCE_35
+  VDDC_0 VDDC_1 VDDC_2 VDDC_3 VDDC_4 VDDC_5 VDDC_6 VDDC_7 VDDC_8 VDDC_9
+  VDDC_10 VDDC_11 VDDC_12 VDDC_13 VDDC_14 VDDC_15 VDDC_16 VDDC_17 VDDC_18
+  VDDC_19 VDDC_20 VDDC_21 VDDC_22 VDDC_23 VDDC_24 VDDC_25 VDDC_26 VDDC_27
+  VDDC_28 VDDC_29 VDDC_30 VDDC_31 VDDC_32 VDDC_33 VDDC_34 VDDC_35 VDDPE_0
+  VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8 VDDPE_9
+  VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16 VDDPE_17
+  VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24 VDDPE_25
+  VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32 VDDPE_33
+  VDDPE_34 VDDPE_35 VNWC_0 VNWC_1 VNWC_2 VNWC_3 VNWC_4 VNWC_5 VNWC_6 VNWC_7
+  VNWC_8 VNWC_9 VNWC_10 VNWC_11 VNWC_12 VNWC_13 VNWC_14 VNWC_15 VNWC_16
+  VNWC_17 VNWC_18 VNWC_19 VNWC_20 VNWC_21 VNWC_22 VNWC_23 VNWC_24 VNWC_25
+  VNWC_26 VNWC_27 VNWC_28 VNWC_29 VNWC_30 VNWC_31 VNWC_32 VNWC_33 VNWC_34
+  VNWC_35 VNWC_36 VNWC_37 VNWP_0 VNWP_1 VPW_0 VPW_1 VPW_2 VPW_3 VPW_4 VPW_5
+  VPW_6 VPW_7 VPW_8 VPW_9 VPW_10 VPW_11 VPW_12 VPW_13 VPW_14 VPW_15 VPW_16
+  VPW_17 VPW_18 VPW_19 VPW_20 VPW_21 VPW_22 VPW_23 VPW_24 VPW_25 VPW_26
+  VPW_27 VPW_28 VPW_29 VPW_30 VPW_31 VPW_32 VPW_33 VPW_34 VPW_35 VSSE WL[0]
+  WL[1]
** sram464x144MEM_L_ROW: 1732 flat devices **
XMEM_L_COL_0 BL[0]_0 BL[1]_0 BL[2]_0 BL[3]_0 CORED00_304 CORED01_306
+  CORED10_308 CORED11_310 CORED20_312 CORED21_314 CORED30_316 CORED31_318
+  NBL[0]_0 NBL[1]_0 NBL[2]_0 NBL[3]_0 NCORED00_320 NCORED01_322 NCORED10_324
+  NCORED11_326 NCORED20_328 NCORED21_330 NCORED30_332 NCORED31_334 VDDC_0
+  VDDCE_0 VDDPE_0 VNWC_1 VPW_0 VSSE WL[0] WL[1] sram464x144CCHD4
XMEM_L_COL_1 BL[0]_1 BL[1]_1 BL[2]_1 BL[3]_1 CORED00_336 CORED01_338
+  CORED10_340 CORED11_342 CORED20_344 CORED21_346 CORED30_348 CORED31_350
+  NBL[0]_1 NBL[1]_1 NBL[2]_1 NBL[3]_1 NCORED00_352 NCORED01_354 NCORED10_356
+  NCORED11_358 NCORED20_360 NCORED21_362 NCORED30_364 NCORED31_366 VDDC_1
+  VDDCE_1 VDDPE_1 VNWC_2 VPW_1 VSSE WL[0] WL[1] sram464x144CCHD4
XMEM_L_COL_10 BL[0]_10 BL[1]_10 BL[2]_10 BL[3]_10 CORED00_624 CORED01_626
+  CORED10_628 CORED11_630 CORED20_632 CORED21_634 CORED30_636 CORED31_638
+  NBL[0]_10 NBL[1]_10 NBL[2]_10 NBL[3]_10 NCORED00_640 NCORED01_642
+  NCORED10_644 NCORED11_646 NCORED20_648 NCORED21_650 NCORED30_652
+  NCORED31_654 VDDC_10 VDDCE_10 VDDPE_10 VNWC_11 VPW_10 VSSE WL[0] WL[1]
+  sram464x144CCHD4
XMEM_L_COL_11 BL[0]_11 BL[1]_11 BL[2]_11 BL[3]_11 CORED00_656 CORED01_658
+  CORED10_660 CORED11_662 CORED20_664 CORED21_666 CORED30_668 CORED31_670
+  NBL[0]_11 NBL[1]_11 NBL[2]_11 NBL[3]_11 NCORED00_672 NCORED01_674
+  NCORED10_676 NCORED11_678 NCORED20_680 NCORED21_682 NCORED30_684
+  NCORED31_686 VDDC_11 VDDCE_11 VDDPE_11 VNWC_12 VPW_11 VSSE WL[0] WL[1]
+  sram464x144CCHD4
XMEM_L_COL_12 BL[0]_12 BL[1]_12 BL[2]_12 BL[3]_12 CORED00_720 CORED01_722
+  CORED10_724 CORED11_726 CORED20_728 CORED21_730 CORED30_732 CORED31_734
+  NBL[0]_12 NBL[1]_12 NBL[2]_12 NBL[3]_12 NCORED00_736 NCORED01_738
+  NCORED10_740 NCORED11_742 NCORED20_744 NCORED21_746 NCORED30_748
+  NCORED31_750 VDDC_12 VDDCE_12 VDDPE_12 VNWC_13 VPW_12 VSSE WL[0] WL[1]
+  sram464x144CCHD4
XMEM_L_COL_13 BL[0]_13 BL[1]_13 BL[2]_13 BL[3]_13 CORED00_784 CORED01_786
+  CORED10_788 CORED11_790 CORED20_792 CORED21_794 CORED30_796 CORED31_798
+  NBL[0]_13 NBL[1]_13 NBL[2]_13 NBL[3]_13 NCORED00_800 NCORED01_802
+  NCORED10_804 NCORED11_806 NCORED20_808 NCORED21_810 NCORED30_812
+  NCORED31_814 VDDC_13 VDDCE_13 VDDPE_13 VNWC_14 VPW_13 VSSE WL[0] WL[1]
+  sram464x144CCHD4
XMEM_L_COL_14 BL[0]_14 BL[1]_14 BL[2]_14 BL[3]_14 CORED00_848 CORED01_850
+  CORED10_852 CORED11_854 CORED20_856 CORED21_858 CORED30_860 CORED31_862
+  NBL[0]_14 NBL[1]_14 NBL[2]_14 NBL[3]_14 NCORED00_864 NCORED01_866
+  NCORED10_868 NCORED11_870 NCORED20_872 NCORED21_874 NCORED30_876
+  NCORED31_878 VDDC_14 VDDCE_14 VDDPE_14 VNWC_15 VPW_14 VSSE WL[0] WL[1]
+  sram464x144CCHD4
XMEM_L_COL_15 BL[0]_15 BL[1]_15 BL[2]_15 BL[3]_15 CORED00_912 CORED01_914
+  CORED10_916 CORED11_918 CORED20_920 CORED21_922 CORED30_924 CORED31_926
+  NBL[0]_15 NBL[1]_15 NBL[2]_15 NBL[3]_15 NCORED00_928 NCORED01_930
+  NCORED10_932 NCORED11_934 NCORED20_936 NCORED21_938 NCORED30_940
+  NCORED31_942 VDDC_15 VDDCE_15 VDDPE_15 VNWC_16 VPW_15 VSSE WL[0] WL[1]
+  sram464x144CCHD4
XMEM_L_COL_16 BL[0]_16 BL[1]_16 BL[2]_16 BL[3]_16 CORED00_976 CORED01_978
+  CORED10_980 CORED11_982 CORED20_984 CORED21_986 CORED30_988 CORED31_990
+  NBL[0]_16 NBL[1]_16 NBL[2]_16 NBL[3]_16 NCORED00_992 NCORED01_994
+  NCORED10_996 NCORED11_998 NCORED20_1000 NCORED21_1002 NCORED30_1004
+  NCORED31_1006 VDDC_16 VDDCE_16 VDDPE_16 VNWC_17 VPW_16 VSSE WL[0] WL[1]
+  sram464x144CCHD4
XMEM_L_COL_17 BL[0]_17 BL[1]_17 BL[2]_17 BL[3]_17 CORED00_1040 CORED01_1042
+  CORED10_1044 CORED11_1046 CORED20_1048 CORED21_1050 CORED30_1052
+  CORED31_1054 NBL[0]_17 NBL[1]_17 NBL[2]_17 NBL[3]_17 NCORED00_1056
+  NCORED01_1058 NCORED10_1060 NCORED11_1062 NCORED20_1064 NCORED21_1066
+  NCORED30_1068 NCORED31_1070 VDDC_17 VDDCE_17 VDDPE_17 VNWC_18 VPW_17 VSSE
+  WL[0] WL[1] sram464x144CCHD4
XMEM_L_COL_18 BL[0]_18 BL[1]_18 BL[2]_18 BL[3]_18 CORED00_1072 CORED01_1074
+  CORED10_1076 CORED11_1078 CORED20_1080 CORED21_1082 CORED30_1084
+  CORED31_1086 NBL[0]_18 NBL[1]_18 NBL[2]_18 NBL[3]_18 NCORED00_1088
+  NCORED01_1090 NCORED10_1092 NCORED11_1094 NCORED20_1096 NCORED21_1098
+  NCORED30_1100 NCORED31_1102 VDDC_18 VDDCE_18 VDDPE_18 VNWC_19 VPW_18 VSSE
+  WL[0] WL[1] sram464x144CCHD4
XMEM_L_COL_19 BL[0]_19 BL[1]_19 BL[2]_19 BL[3]_19 CORED00_1104 CORED01_1106
+  CORED10_1108 CORED11_1110 CORED20_1112 CORED21_1114 CORED30_1116
+  CORED31_1118 NBL[0]_19 NBL[1]_19 NBL[2]_19 NBL[3]_19 NCORED00_1120
+  NCORED01_1122 NCORED10_1124 NCORED11_1126 NCORED20_1128 NCORED21_1130
+  NCORED30_1132 NCORED31_1134 VDDC_19 VDDCE_19 VDDPE_19 VNWC_20 VPW_19 VSSE
+  WL[0] WL[1] sram464x144CCHD4
XMEM_L_COL_2 BL[0]_2 BL[1]_2 BL[2]_2 BL[3]_2 CORED00_368 CORED01_370
+  CORED10_372 CORED11_374 CORED20_376 CORED21_378 CORED30_380 CORED31_382
+  NBL[0]_2 NBL[1]_2 NBL[2]_2 NBL[3]_2 NCORED00_384 NCORED01_386 NCORED10_388
+  NCORED11_390 NCORED20_392 NCORED21_394 NCORED30_396 NCORED31_398 VDDC_2
+  VDDCE_2 VDDPE_2 VNWC_3 VPW_2 VSSE WL[0] WL[1] sram464x144CCHD4
XMEM_L_COL_20 BL[0]_20 BL[1]_20 BL[2]_20 BL[3]_20 CORED00 CORED01 CORED10
+  CORED11 CORED20 CORED21 CORED30 CORED31 NBL[0]_20 NBL[1]_20 NBL[2]_20
+  NBL[3]_20 NCORED00 NCORED01 NCORED10 NCORED11 NCORED20 NCORED21 NCORED30
+  NCORED31 VDDC_20 VDDCE_20 VDDPE_20 VNWC_21 VPW_20 VSSE WL[0] WL[1]
+  sram464x144CCHD4
XMEM_L_COL_21 BL[0]_21 BL[1]_21 BL[2]_21 BL[3]_21 CORED00_16 CORED01_18
+  CORED10_20 CORED11_22 CORED20_24 CORED21_26 CORED30_28 CORED31_30 NBL[0]_21
+  NBL[1]_21 NBL[2]_21 NBL[3]_21 NCORED00_32 NCORED01_34 NCORED10_36
+  NCORED11_38 NCORED20_40 NCORED21_42 NCORED30_44 NCORED31_46 VDDC_21
+  VDDCE_21 VDDPE_21 VNWC_22 VPW_21 VSSE WL[0] WL[1] sram464x144CCHD4
XMEM_L_COL_22 BL[0]_22 BL[1]_22 BL[2]_22 BL[3]_22 CORED00_48 CORED01_50
+  CORED10_52 CORED11_54 CORED20_56 CORED21_58 CORED30_60 CORED31_62 NBL[0]_22
+  NBL[1]_22 NBL[2]_22 NBL[3]_22 NCORED00_64 NCORED01_66 NCORED10_68
+  NCORED11_70 NCORED20_72 NCORED21_74 NCORED30_76 NCORED31_78 VDDC_22
+  VDDCE_22 VDDPE_22 VNWC_23 VPW_22 VSSE WL[0] WL[1] sram464x144CCHD4
XMEM_L_COL_23 BL[0]_23 BL[1]_23 BL[2]_23 BL[3]_23 CORED00_80 CORED01_82
+  CORED10_84 CORED11_86 CORED20_88 CORED21_90 CORED30_92 CORED31_94 NBL[0]_23
+  NBL[1]_23 NBL[2]_23 NBL[3]_23 NCORED00_96 NCORED01_98 NCORED10_100
+  NCORED11_102 NCORED20_104 NCORED21_106 NCORED30_108 NCORED31_110 VDDC_23
+  VDDCE_23 VDDPE_23 VNWC_24 VPW_23 VSSE WL[0] WL[1] sram464x144CCHD4
XMEM_L_COL_24 BL[0]_24 BL[1]_24 BL[2]_24 BL[3]_24 CORED00_112 CORED01_114
+  CORED10_116 CORED11_118 CORED20_120 CORED21_122 CORED30_124 CORED31_126
+  NBL[0]_24 NBL[1]_24 NBL[2]_24 NBL[3]_24 NCORED00_128 NCORED01_130
+  NCORED10_132 NCORED11_134 NCORED20_136 NCORED21_138 NCORED30_140
+  NCORED31_142 VDDC_24 VDDCE_24 VDDPE_24 VNWC_25 VPW_24 VSSE WL[0] WL[1]
+  sram464x144CCHD4
XMEM_L_COL_25 BL[0]_25 BL[1]_25 BL[2]_25 BL[3]_25 CORED00_144 CORED01_146
+  CORED10_148 CORED11_150 CORED20_152 CORED21_154 CORED30_156 CORED31_158
+  NBL[0]_25 NBL[1]_25 NBL[2]_25 NBL[3]_25 NCORED00_160 NCORED01_162
+  NCORED10_164 NCORED11_166 NCORED20_168 NCORED21_170 NCORED30_172
+  NCORED31_174 VDDC_25 VDDCE_25 VDDPE_25 VNWC_26 VPW_25 VSSE WL[0] WL[1]
+  sram464x144CCHD4
XMEM_L_COL_26 BL[0]_26 BL[1]_26 BL[2]_26 BL[3]_26 CORED00_176 CORED01_178
+  CORED10_180 CORED11_182 CORED20_184 CORED21_186 CORED30_188 CORED31_190
+  NBL[0]_26 NBL[1]_26 NBL[2]_26 NBL[3]_26 NCORED00_192 NCORED01_194
+  NCORED10_196 NCORED11_198 NCORED20_200 NCORED21_202 NCORED30_204
+  NCORED31_206 VDDC_26 VDDCE_26 VDDPE_26 VNWC_27 VPW_26 VSSE WL[0] WL[1]
+  sram464x144CCHD4
XMEM_L_COL_27 BL[0]_27 BL[1]_27 BL[2]_27 BL[3]_27 CORED00_208 CORED01_210
+  CORED10_212 CORED11_214 CORED20_216 CORED21_218 CORED30_220 CORED31_222
+  NBL[0]_27 NBL[1]_27 NBL[2]_27 NBL[3]_27 NCORED00_224 NCORED01_226
+  NCORED10_228 NCORED11_230 NCORED20_232 NCORED21_234 NCORED30_236
+  NCORED31_238 VDDC_27 VDDCE_27 VDDPE_27 VNWC_28 VPW_27 VSSE WL[0] WL[1]
+  sram464x144CCHD4
XMEM_L_COL_28 BL[0]_28 BL[1]_28 BL[2]_28 BL[3]_28 CORED00_240 CORED01_242
+  CORED10_244 CORED11_246 CORED20_248 CORED21_250 CORED30_252 CORED31_254
+  NBL[0]_28 NBL[1]_28 NBL[2]_28 NBL[3]_28 NCORED00_256 NCORED01_258
+  NCORED10_260 NCORED11_262 NCORED20_264 NCORED21_266 NCORED30_268
+  NCORED31_270 VDDC_28 VDDCE_28 VDDPE_28 VNWC_29 VPW_28 VSSE WL[0] WL[1]
+  sram464x144CCHD4
XMEM_L_COL_29 BL[0]_29 BL[1]_29 BL[2]_29 BL[3]_29 CORED00_272 CORED01_274
+  CORED10_276 CORED11_278 CORED20_280 CORED21_282 CORED30_284 CORED31_286
+  NBL[0]_29 NBL[1]_29 NBL[2]_29 NBL[3]_29 NCORED00_288 NCORED01_290
+  NCORED10_292 NCORED11_294 NCORED20_296 NCORED21_298 NCORED30_300
+  NCORED31_302 VDDC_29 VDDCE_29 VDDPE_29 VNWC_30 VPW_29 VSSE WL[0] WL[1]
+  sram464x144CCHD4
XMEM_L_COL_3 BL[0]_3 BL[1]_3 BL[2]_3 BL[3]_3 CORED00_400 CORED01_402
+  CORED10_404 CORED11_406 CORED20_408 CORED21_410 CORED30_412 CORED31_414
+  NBL[0]_3 NBL[1]_3 NBL[2]_3 NBL[3]_3 NCORED00_416 NCORED01_418 NCORED10_420
+  NCORED11_422 NCORED20_424 NCORED21_426 NCORED30_428 NCORED31_430 VDDC_3
+  VDDCE_3 VDDPE_3 VNWC_4 VPW_3 VSSE WL[0] WL[1] sram464x144CCHD4
XMEM_L_COL_30 BL[0]_30 BL[1]_30 BL[2]_30 BL[3]_30 CORED00_688 CORED01_690
+  CORED10_692 CORED11_694 CORED20_696 CORED21_698 CORED30_700 CORED31_702
+  NBL[0]_30 NBL[1]_30 NBL[2]_30 NBL[3]_30 NCORED00_704 NCORED01_706
+  NCORED10_708 NCORED11_710 NCORED20_712 NCORED21_714 NCORED30_716
+  NCORED31_718 VDDC_30 VDDCE_30 VDDPE_30 VNWC_31 VPW_30 VSSE WL[0] WL[1]
+  sram464x144CCHD4
XMEM_L_COL_31 BL[0]_31 BL[1]_31 BL[2]_31 BL[3]_31 CORED00_752 CORED01_754
+  CORED10_756 CORED11_758 CORED20_760 CORED21_762 CORED30_764 CORED31_766
+  NBL[0]_31 NBL[1]_31 NBL[2]_31 NBL[3]_31 NCORED00_768 NCORED01_770
+  NCORED10_772 NCORED11_774 NCORED20_776 NCORED21_778 NCORED30_780
+  NCORED31_782 VDDC_31 VDDCE_31 VDDPE_31 VNWC_32 VPW_31 VSSE WL[0] WL[1]
+  sram464x144CCHD4
XMEM_L_COL_32 BL[0]_32 BL[1]_32 BL[2]_32 BL[3]_32 CORED00_816 CORED01_818
+  CORED10_820 CORED11_822 CORED20_824 CORED21_826 CORED30_828 CORED31_830
+  NBL[0]_32 NBL[1]_32 NBL[2]_32 NBL[3]_32 NCORED00_832 NCORED01_834
+  NCORED10_836 NCORED11_838 NCORED20_840 NCORED21_842 NCORED30_844
+  NCORED31_846 VDDC_32 VDDCE_32 VDDPE_32 VNWC_33 VPW_32 VSSE WL[0] WL[1]
+  sram464x144CCHD4
XMEM_L_COL_33 BL[0]_33 BL[1]_33 BL[2]_33 BL[3]_33 CORED00_880 CORED01_882
+  CORED10_884 CORED11_886 CORED20_888 CORED21_890 CORED30_892 CORED31_894
+  NBL[0]_33 NBL[1]_33 NBL[2]_33 NBL[3]_33 NCORED00_896 NCORED01_898
+  NCORED10_900 NCORED11_902 NCORED20_904 NCORED21_906 NCORED30_908
+  NCORED31_910 VDDC_33 VDDCE_33 VDDPE_33 VNWC_34 VPW_33 VSSE WL[0] WL[1]
+  sram464x144CCHD4
XMEM_L_COL_34 BL[0]_34 BL[1]_34 BL[2]_34 BL[3]_34 CORED00_944 CORED01_946
+  CORED10_948 CORED11_950 CORED20_952 CORED21_954 CORED30_956 CORED31_958
+  NBL[0]_34 NBL[1]_34 NBL[2]_34 NBL[3]_34 NCORED00_960 NCORED01_962
+  NCORED10_964 NCORED11_966 NCORED20_968 NCORED21_970 NCORED30_972
+  NCORED31_974 VDDC_34 VDDCE_34 VDDPE_34 VNWC_35 VPW_34 VSSE WL[0] WL[1]
+  sram464x144CCHD4
XMEM_L_COL_35 BL[0]_35 BL[1]_35 BL[2]_35 BL[3]_35 CORED00_1008 CORED01_1010
+  CORED10_1012 CORED11_1014 CORED20_1016 CORED21_1018 CORED30_1020
+  CORED31_1022 NBL[0]_35 NBL[1]_35 NBL[2]_35 NBL[3]_35 NCORED00_1024
+  NCORED01_1026 NCORED10_1028 NCORED11_1030 NCORED20_1032 NCORED21_1034
+  NCORED30_1036 NCORED31_1038 VDDC_35 VDDCE_35 VDDPE_35 VNWC_36 VPW_35 VSSE
+  WL[0] WL[1] sram464x144CCHD4
XMEM_L_COL_4 BL[0]_4 BL[1]_4 BL[2]_4 BL[3]_4 CORED00_432 CORED01_434
+  CORED10_436 CORED11_438 CORED20_440 CORED21_442 CORED30_444 CORED31_446
+  NBL[0]_4 NBL[1]_4 NBL[2]_4 NBL[3]_4 NCORED00_448 NCORED01_450 NCORED10_452
+  NCORED11_454 NCORED20_456 NCORED21_458 NCORED30_460 NCORED31_462 VDDC_4
+  VDDCE_4 VDDPE_4 VNWC_5 VPW_4 VSSE WL[0] WL[1] sram464x144CCHD4
XMEM_L_COL_5 BL[0]_5 BL[1]_5 BL[2]_5 BL[3]_5 CORED00_464 CORED01_466
+  CORED10_468 CORED11_470 CORED20_472 CORED21_474 CORED30_476 CORED31_478
+  NBL[0]_5 NBL[1]_5 NBL[2]_5 NBL[3]_5 NCORED00_480 NCORED01_482 NCORED10_484
+  NCORED11_486 NCORED20_488 NCORED21_490 NCORED30_492 NCORED31_494 VDDC_5
+  VDDCE_5 VDDPE_5 VNWC_6 VPW_5 VSSE WL[0] WL[1] sram464x144CCHD4
XMEM_L_COL_6 BL[0]_6 BL[1]_6 BL[2]_6 BL[3]_6 CORED00_496 CORED01_498
+  CORED10_500 CORED11_502 CORED20_504 CORED21_506 CORED30_508 CORED31_510
+  NBL[0]_6 NBL[1]_6 NBL[2]_6 NBL[3]_6 NCORED00_512 NCORED01_514 NCORED10_516
+  NCORED11_518 NCORED20_520 NCORED21_522 NCORED30_524 NCORED31_526 VDDC_6
+  VDDCE_6 VDDPE_6 VNWC_7 VPW_6 VSSE WL[0] WL[1] sram464x144CCHD4
XMEM_L_COL_7 BL[0]_7 BL[1]_7 BL[2]_7 BL[3]_7 CORED00_528 CORED01_530
+  CORED10_532 CORED11_534 CORED20_536 CORED21_538 CORED30_540 CORED31_542
+  NBL[0]_7 NBL[1]_7 NBL[2]_7 NBL[3]_7 NCORED00_544 NCORED01_546 NCORED10_548
+  NCORED11_550 NCORED20_552 NCORED21_554 NCORED30_556 NCORED31_558 VDDC_7
+  VDDCE_7 VDDPE_7 VNWC_8 VPW_7 VSSE WL[0] WL[1] sram464x144CCHD4
XMEM_L_COL_8 BL[0]_8 BL[1]_8 BL[2]_8 BL[3]_8 CORED00_560 CORED01_562
+  CORED10_564 CORED11_566 CORED20_568 CORED21_570 CORED30_572 CORED31_574
+  NBL[0]_8 NBL[1]_8 NBL[2]_8 NBL[3]_8 NCORED00_576 NCORED01_578 NCORED10_580
+  NCORED11_582 NCORED20_584 NCORED21_586 NCORED30_588 NCORED31_590 VDDC_8
+  VDDCE_8 VDDPE_8 VNWC_9 VPW_8 VSSE WL[0] WL[1] sram464x144CCHD4
XMEM_L_COL_9 BL[0]_9 BL[1]_9 BL[2]_9 BL[3]_9 CORED00_592 CORED01_594
+  CORED10_596 CORED11_598 CORED20_600 CORED21_602 CORED30_604 CORED31_606
+  NBL[0]_9 NBL[1]_9 NBL[2]_9 NBL[3]_9 NCORED00_608 NCORED01_610 NCORED10_612
+  NCORED11_614 NCORED20_616 NCORED21_618 NCORED30_620 NCORED31_622 VDDC_9
+  VDDCE_9 VDDPE_9 VNWC_10 VPW_9 VSSE WL[0] WL[1] sram464x144CCHD4
XMEM_L_COL_EDGEL VNWC_0 VNWP_0 VSSE VSSE WL[0] WL[1] sram464x144CCHD4_EDG
XMEM_L_COL_EDGER VNWC_37 VNWP_1 VSSE VSSE WL[0] WL[1] sram464x144CCHD4WD_EDG
.ENDS sram464x144MEM_L_ROW
****
.SUBCKT sram464x144MEM_L_MIDT_ROW BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4
+  BL[0]_5 BL[0]_6 BL[0]_7 BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13
+  BL[0]_14 BL[0]_15 BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21
+  BL[0]_22 BL[0]_23 BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29
+  BL[0]_30 BL[0]_31 BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1
+  BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10
+  BL[1]_11 BL[1]_12 BL[1]_13 BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18
+  BL[1]_19 BL[1]_20 BL[1]_21 BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26
+  BL[1]_27 BL[1]_28 BL[1]_29 BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34
+  BL[1]_35 BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7
+  BL[2]_8 BL[2]_9 BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15
+  BL[2]_16 BL[2]_17 BL[2]_18 BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23
+  BL[2]_24 BL[2]_25 BL[2]_26 BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31
+  BL[2]_32 BL[2]_33 BL[2]_34 BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4
+  BL[3]_5 BL[3]_6 BL[3]_7 BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13
+  BL[3]_14 BL[3]_15 BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21
+  BL[3]_22 BL[3]_23 BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29
+  BL[3]_30 BL[3]_31 BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1
+  NBL[0]_2 NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9
+  NBL[0]_10 NBL[0]_11 NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16
+  NBL[0]_17 NBL[0]_18 NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23
+  NBL[0]_24 NBL[0]_25 NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30
+  NBL[0]_31 NBL[0]_32 NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1
+  NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9
+  NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16
+  NBL[1]_17 NBL[1]_18 NBL[1]_19 NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23
+  NBL[1]_24 NBL[1]_25 NBL[1]_26 NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30
+  NBL[1]_31 NBL[1]_32 NBL[1]_33 NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1
+  NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9
+  NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13 NBL[2]_14 NBL[2]_15 NBL[2]_16
+  NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20 NBL[2]_21 NBL[2]_22 NBL[2]_23
+  NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27 NBL[2]_28 NBL[2]_29 NBL[2]_30
+  NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34 NBL[2]_35 NBL[3]_0 NBL[3]_1
+  NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 NBL[3]_8 NBL[3]_9
+  NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13 NBL[3]_14 NBL[3]_15 NBL[3]_16
+  NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20 NBL[3]_21 NBL[3]_22 NBL[3]_23
+  NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27 NBL[3]_28 NBL[3]_29 NBL[3]_30
+  NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34 NBL[3]_35 VDDCE_0 VDDCE_1 VDDCE_2
+  VDDCE_3 VDDCE_4 VDDCE_5 VDDCE_6 VDDCE_7 VDDCE_8 VDDCE_9 VDDCE_10 VDDCE_11
+  VDDCE_12 VDDCE_13 VDDCE_14 VDDCE_15 VDDCE_16 VDDCE_17 VDDCE_18 VDDCE_19
+  VDDCE_20 VDDCE_21 VDDCE_22 VDDCE_23 VDDCE_24 VDDCE_25 VDDCE_26 VDDCE_27
+  VDDCE_28 VDDCE_29 VDDCE_30 VDDCE_31 VDDCE_32 VDDCE_33 VDDCE_34 VDDCE_35
+  VDDC_0 VDDC_1 VDDC_2 VDDC_3 VDDC_4 VDDC_5 VDDC_6 VDDC_7 VDDC_8 VDDC_9
+  VDDC_10 VDDC_11 VDDC_12 VDDC_13 VDDC_14 VDDC_15 VDDC_16 VDDC_17 VDDC_18
+  VDDC_19 VDDC_20 VDDC_21 VDDC_22 VDDC_23 VDDC_24 VDDC_25 VDDC_26 VDDC_27
+  VDDC_28 VDDC_29 VDDC_30 VDDC_31 VDDC_32 VDDC_33 VDDC_34 VDDC_35 VDDPE_0
+  VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8 VDDPE_9
+  VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16 VDDPE_17
+  VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24 VDDPE_25
+  VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32 VDDPE_33
+  VDDPE_34 VDDPE_35 VNWC_0 VNWC_1 VNWC_2 VNWC_3 VNWC_4 VNWC_5 VNWC_6 VNWC_7
+  VNWC_8 VNWC_9 VNWC_10 VNWC_11 VNWC_12 VNWC_13 VNWC_14 VNWC_15 VNWC_16
+  VNWC_17 VNWC_18 VNWC_19 VNWC_20 VNWC_21 VNWC_22 VNWC_23 VNWC_24 VNWC_25
+  VNWC_26 VNWC_27 VNWC_28 VNWC_29 VNWC_30 VNWC_31 VNWC_32 VNWC_33 VNWC_34
+  VNWC_35 VNWC_36 VNWC_37 VNWP_0 VNWP_1 VPW_0 VPW_1 VPW_2 VPW_3 VPW_4 VPW_5
+  VPW_6 VPW_7 VPW_8 VPW_9 VPW_10 VPW_11 VPW_12 VPW_13 VPW_14 VPW_15 VPW_16
+  VPW_17 VPW_18 VPW_19 VPW_20 VPW_21 VPW_22 VPW_23 VPW_24 VPW_25 VPW_26
+  VPW_27 VPW_28 VPW_29 VPW_30 VPW_31 VPW_32 VPW_33 VPW_34 VPW_35 VSSE WL[0]
+  WL[1]
** sram464x144MEM_L_MIDT_ROW: 1732 flat devices **
XMEM_L_COL_0 BL[0]_0 BL[1]_0 BL[2]_0 BL[3]_0 CORED00_304 CORED01_306
+  CORED10_308 CORED11_310 CORED20_312 CORED21_314 CORED30_316 CORED31_318
+  NBL[0]_0 NBL[1]_0 NBL[2]_0 NBL[3]_0 NCORED00_320 NCORED01_322 NCORED10_324
+  NCORED11_326 NCORED20_328 NCORED21_330 NCORED30_332 NCORED31_334 VDDC_0
+  VDDCE_0 VDDPE_0 VNWC_1 VPW_0 VSSE WL[0] WL[1] sram464x144CCHD4
XMEM_L_COL_1 BL[0]_1 BL[1]_1 BL[2]_1 BL[3]_1 CORED00_336 CORED01_338
+  CORED10_340 CORED11_342 CORED20_344 CORED21_346 CORED30_348 CORED31_350
+  NBL[0]_1 NBL[1]_1 NBL[2]_1 NBL[3]_1 NCORED00_352 NCORED01_354 NCORED10_356
+  NCORED11_358 NCORED20_360 NCORED21_362 NCORED30_364 NCORED31_366 VDDC_1
+  VDDCE_1 VDDPE_1 VNWC_2 VPW_1 VSSE WL[0] WL[1] sram464x144CCHD4
XMEM_L_COL_10 BL[0]_10 BL[1]_10 BL[2]_10 BL[3]_10 CORED00_624 CORED01_626
+  CORED10_628 CORED11_630 CORED20_632 CORED21_634 CORED30_636 CORED31_638
+  NBL[0]_10 NBL[1]_10 NBL[2]_10 NBL[3]_10 NCORED00_640 NCORED01_642
+  NCORED10_644 NCORED11_646 NCORED20_648 NCORED21_650 NCORED30_652
+  NCORED31_654 VDDC_10 VDDCE_10 VDDPE_10 VNWC_11 VPW_10 VSSE WL[0] WL[1]
+  sram464x144CCHD4
XMEM_L_COL_11 BL[0]_11 BL[1]_11 BL[2]_11 BL[3]_11 CORED00_656 CORED01_658
+  CORED10_660 CORED11_662 CORED20_664 CORED21_666 CORED30_668 CORED31_670
+  NBL[0]_11 NBL[1]_11 NBL[2]_11 NBL[3]_11 NCORED00_672 NCORED01_674
+  NCORED10_676 NCORED11_678 NCORED20_680 NCORED21_682 NCORED30_684
+  NCORED31_686 VDDC_11 VDDCE_11 VDDPE_11 VNWC_12 VPW_11 VSSE WL[0] WL[1]
+  sram464x144CCHD4
XMEM_L_COL_12 BL[0]_12 BL[1]_12 BL[2]_12 BL[3]_12 CORED00_720 CORED01_722
+  CORED10_724 CORED11_726 CORED20_728 CORED21_730 CORED30_732 CORED31_734
+  NBL[0]_12 NBL[1]_12 NBL[2]_12 NBL[3]_12 NCORED00_736 NCORED01_738
+  NCORED10_740 NCORED11_742 NCORED20_744 NCORED21_746 NCORED30_748
+  NCORED31_750 VDDC_12 VDDCE_12 VDDPE_12 VNWC_13 VPW_12 VSSE WL[0] WL[1]
+  sram464x144CCHD4
XMEM_L_COL_13 BL[0]_13 BL[1]_13 BL[2]_13 BL[3]_13 CORED00_784 CORED01_786
+  CORED10_788 CORED11_790 CORED20_792 CORED21_794 CORED30_796 CORED31_798
+  NBL[0]_13 NBL[1]_13 NBL[2]_13 NBL[3]_13 NCORED00_800 NCORED01_802
+  NCORED10_804 NCORED11_806 NCORED20_808 NCORED21_810 NCORED30_812
+  NCORED31_814 VDDC_13 VDDCE_13 VDDPE_13 VNWC_14 VPW_13 VSSE WL[0] WL[1]
+  sram464x144CCHD4
XMEM_L_COL_14 BL[0]_14 BL[1]_14 BL[2]_14 BL[3]_14 CORED00_848 CORED01_850
+  CORED10_852 CORED11_854 CORED20_856 CORED21_858 CORED30_860 CORED31_862
+  NBL[0]_14 NBL[1]_14 NBL[2]_14 NBL[3]_14 NCORED00_864 NCORED01_866
+  NCORED10_868 NCORED11_870 NCORED20_872 NCORED21_874 NCORED30_876
+  NCORED31_878 VDDC_14 VDDCE_14 VDDPE_14 VNWC_15 VPW_14 VSSE WL[0] WL[1]
+  sram464x144CCHD4
XMEM_L_COL_15 BL[0]_15 BL[1]_15 BL[2]_15 BL[3]_15 CORED00_912 CORED01_914
+  CORED10_916 CORED11_918 CORED20_920 CORED21_922 CORED30_924 CORED31_926
+  NBL[0]_15 NBL[1]_15 NBL[2]_15 NBL[3]_15 NCORED00_928 NCORED01_930
+  NCORED10_932 NCORED11_934 NCORED20_936 NCORED21_938 NCORED30_940
+  NCORED31_942 VDDC_15 VDDCE_15 VDDPE_15 VNWC_16 VPW_15 VSSE WL[0] WL[1]
+  sram464x144CCHD4
XMEM_L_COL_16 BL[0]_16 BL[1]_16 BL[2]_16 BL[3]_16 CORED00_976 CORED01_978
+  CORED10_980 CORED11_982 CORED20_984 CORED21_986 CORED30_988 CORED31_990
+  NBL[0]_16 NBL[1]_16 NBL[2]_16 NBL[3]_16 NCORED00_992 NCORED01_994
+  NCORED10_996 NCORED11_998 NCORED20_1000 NCORED21_1002 NCORED30_1004
+  NCORED31_1006 VDDC_16 VDDCE_16 VDDPE_16 VNWC_17 VPW_16 VSSE WL[0] WL[1]
+  sram464x144CCHD4
XMEM_L_COL_17 BL[0]_17 BL[1]_17 BL[2]_17 BL[3]_17 CORED00_1040 CORED01_1042
+  CORED10_1044 CORED11_1046 CORED20_1048 CORED21_1050 CORED30_1052
+  CORED31_1054 NBL[0]_17 NBL[1]_17 NBL[2]_17 NBL[3]_17 NCORED00_1056
+  NCORED01_1058 NCORED10_1060 NCORED11_1062 NCORED20_1064 NCORED21_1066
+  NCORED30_1068 NCORED31_1070 VDDC_17 VDDCE_17 VDDPE_17 VNWC_18 VPW_17 VSSE
+  WL[0] WL[1] sram464x144CCHD4
XMEM_L_COL_18 BL[0]_18 BL[1]_18 BL[2]_18 BL[3]_18 CORED00_1072 CORED01_1074
+  CORED10_1076 CORED11_1078 CORED20_1080 CORED21_1082 CORED30_1084
+  CORED31_1086 NBL[0]_18 NBL[1]_18 NBL[2]_18 NBL[3]_18 NCORED00_1088
+  NCORED01_1090 NCORED10_1092 NCORED11_1094 NCORED20_1096 NCORED21_1098
+  NCORED30_1100 NCORED31_1102 VDDC_18 VDDCE_18 VDDPE_18 VNWC_19 VPW_18 VSSE
+  WL[0] WL[1] sram464x144CCHD4
XMEM_L_COL_19 BL[0]_19 BL[1]_19 BL[2]_19 BL[3]_19 CORED00_1104 CORED01_1106
+  CORED10_1108 CORED11_1110 CORED20_1112 CORED21_1114 CORED30_1116
+  CORED31_1118 NBL[0]_19 NBL[1]_19 NBL[2]_19 NBL[3]_19 NCORED00_1120
+  NCORED01_1122 NCORED10_1124 NCORED11_1126 NCORED20_1128 NCORED21_1130
+  NCORED30_1132 NCORED31_1134 VDDC_19 VDDCE_19 VDDPE_19 VNWC_20 VPW_19 VSSE
+  WL[0] WL[1] sram464x144CCHD4
XMEM_L_COL_2 BL[0]_2 BL[1]_2 BL[2]_2 BL[3]_2 CORED00_368 CORED01_370
+  CORED10_372 CORED11_374 CORED20_376 CORED21_378 CORED30_380 CORED31_382
+  NBL[0]_2 NBL[1]_2 NBL[2]_2 NBL[3]_2 NCORED00_384 NCORED01_386 NCORED10_388
+  NCORED11_390 NCORED20_392 NCORED21_394 NCORED30_396 NCORED31_398 VDDC_2
+  VDDCE_2 VDDPE_2 VNWC_3 VPW_2 VSSE WL[0] WL[1] sram464x144CCHD4
XMEM_L_COL_20 BL[0]_20 BL[1]_20 BL[2]_20 BL[3]_20 CORED00 CORED01 CORED10
+  CORED11 CORED20 CORED21 CORED30 CORED31 NBL[0]_20 NBL[1]_20 NBL[2]_20
+  NBL[3]_20 NCORED00 NCORED01 NCORED10 NCORED11 NCORED20 NCORED21 NCORED30
+  NCORED31 VDDC_20 VDDCE_20 VDDPE_20 VNWC_21 VPW_20 VSSE WL[0] WL[1]
+  sram464x144CCHD4
XMEM_L_COL_21 BL[0]_21 BL[1]_21 BL[2]_21 BL[3]_21 CORED00_16 CORED01_18
+  CORED10_20 CORED11_22 CORED20_24 CORED21_26 CORED30_28 CORED31_30 NBL[0]_21
+  NBL[1]_21 NBL[2]_21 NBL[3]_21 NCORED00_32 NCORED01_34 NCORED10_36
+  NCORED11_38 NCORED20_40 NCORED21_42 NCORED30_44 NCORED31_46 VDDC_21
+  VDDCE_21 VDDPE_21 VNWC_22 VPW_21 VSSE WL[0] WL[1] sram464x144CCHD4
XMEM_L_COL_22 BL[0]_22 BL[1]_22 BL[2]_22 BL[3]_22 CORED00_48 CORED01_50
+  CORED10_52 CORED11_54 CORED20_56 CORED21_58 CORED30_60 CORED31_62 NBL[0]_22
+  NBL[1]_22 NBL[2]_22 NBL[3]_22 NCORED00_64 NCORED01_66 NCORED10_68
+  NCORED11_70 NCORED20_72 NCORED21_74 NCORED30_76 NCORED31_78 VDDC_22
+  VDDCE_22 VDDPE_22 VNWC_23 VPW_22 VSSE WL[0] WL[1] sram464x144CCHD4
XMEM_L_COL_23 BL[0]_23 BL[1]_23 BL[2]_23 BL[3]_23 CORED00_80 CORED01_82
+  CORED10_84 CORED11_86 CORED20_88 CORED21_90 CORED30_92 CORED31_94 NBL[0]_23
+  NBL[1]_23 NBL[2]_23 NBL[3]_23 NCORED00_96 NCORED01_98 NCORED10_100
+  NCORED11_102 NCORED20_104 NCORED21_106 NCORED30_108 NCORED31_110 VDDC_23
+  VDDCE_23 VDDPE_23 VNWC_24 VPW_23 VSSE WL[0] WL[1] sram464x144CCHD4
XMEM_L_COL_24 BL[0]_24 BL[1]_24 BL[2]_24 BL[3]_24 CORED00_112 CORED01_114
+  CORED10_116 CORED11_118 CORED20_120 CORED21_122 CORED30_124 CORED31_126
+  NBL[0]_24 NBL[1]_24 NBL[2]_24 NBL[3]_24 NCORED00_128 NCORED01_130
+  NCORED10_132 NCORED11_134 NCORED20_136 NCORED21_138 NCORED30_140
+  NCORED31_142 VDDC_24 VDDCE_24 VDDPE_24 VNWC_25 VPW_24 VSSE WL[0] WL[1]
+  sram464x144CCHD4
XMEM_L_COL_25 BL[0]_25 BL[1]_25 BL[2]_25 BL[3]_25 CORED00_144 CORED01_146
+  CORED10_148 CORED11_150 CORED20_152 CORED21_154 CORED30_156 CORED31_158
+  NBL[0]_25 NBL[1]_25 NBL[2]_25 NBL[3]_25 NCORED00_160 NCORED01_162
+  NCORED10_164 NCORED11_166 NCORED20_168 NCORED21_170 NCORED30_172
+  NCORED31_174 VDDC_25 VDDCE_25 VDDPE_25 VNWC_26 VPW_25 VSSE WL[0] WL[1]
+  sram464x144CCHD4
XMEM_L_COL_26 BL[0]_26 BL[1]_26 BL[2]_26 BL[3]_26 CORED00_176 CORED01_178
+  CORED10_180 CORED11_182 CORED20_184 CORED21_186 CORED30_188 CORED31_190
+  NBL[0]_26 NBL[1]_26 NBL[2]_26 NBL[3]_26 NCORED00_192 NCORED01_194
+  NCORED10_196 NCORED11_198 NCORED20_200 NCORED21_202 NCORED30_204
+  NCORED31_206 VDDC_26 VDDCE_26 VDDPE_26 VNWC_27 VPW_26 VSSE WL[0] WL[1]
+  sram464x144CCHD4
XMEM_L_COL_27 BL[0]_27 BL[1]_27 BL[2]_27 BL[3]_27 CORED00_208 CORED01_210
+  CORED10_212 CORED11_214 CORED20_216 CORED21_218 CORED30_220 CORED31_222
+  NBL[0]_27 NBL[1]_27 NBL[2]_27 NBL[3]_27 NCORED00_224 NCORED01_226
+  NCORED10_228 NCORED11_230 NCORED20_232 NCORED21_234 NCORED30_236
+  NCORED31_238 VDDC_27 VDDCE_27 VDDPE_27 VNWC_28 VPW_27 VSSE WL[0] WL[1]
+  sram464x144CCHD4
XMEM_L_COL_28 BL[0]_28 BL[1]_28 BL[2]_28 BL[3]_28 CORED00_240 CORED01_242
+  CORED10_244 CORED11_246 CORED20_248 CORED21_250 CORED30_252 CORED31_254
+  NBL[0]_28 NBL[1]_28 NBL[2]_28 NBL[3]_28 NCORED00_256 NCORED01_258
+  NCORED10_260 NCORED11_262 NCORED20_264 NCORED21_266 NCORED30_268
+  NCORED31_270 VDDC_28 VDDCE_28 VDDPE_28 VNWC_29 VPW_28 VSSE WL[0] WL[1]
+  sram464x144CCHD4
XMEM_L_COL_29 BL[0]_29 BL[1]_29 BL[2]_29 BL[3]_29 CORED00_272 CORED01_274
+  CORED10_276 CORED11_278 CORED20_280 CORED21_282 CORED30_284 CORED31_286
+  NBL[0]_29 NBL[1]_29 NBL[2]_29 NBL[3]_29 NCORED00_288 NCORED01_290
+  NCORED10_292 NCORED11_294 NCORED20_296 NCORED21_298 NCORED30_300
+  NCORED31_302 VDDC_29 VDDCE_29 VDDPE_29 VNWC_30 VPW_29 VSSE WL[0] WL[1]
+  sram464x144CCHD4
XMEM_L_COL_3 BL[0]_3 BL[1]_3 BL[2]_3 BL[3]_3 CORED00_400 CORED01_402
+  CORED10_404 CORED11_406 CORED20_408 CORED21_410 CORED30_412 CORED31_414
+  NBL[0]_3 NBL[1]_3 NBL[2]_3 NBL[3]_3 NCORED00_416 NCORED01_418 NCORED10_420
+  NCORED11_422 NCORED20_424 NCORED21_426 NCORED30_428 NCORED31_430 VDDC_3
+  VDDCE_3 VDDPE_3 VNWC_4 VPW_3 VSSE WL[0] WL[1] sram464x144CCHD4
XMEM_L_COL_30 BL[0]_30 BL[1]_30 BL[2]_30 BL[3]_30 CORED00_688 CORED01_690
+  CORED10_692 CORED11_694 CORED20_696 CORED21_698 CORED30_700 CORED31_702
+  NBL[0]_30 NBL[1]_30 NBL[2]_30 NBL[3]_30 NCORED00_704 NCORED01_706
+  NCORED10_708 NCORED11_710 NCORED20_712 NCORED21_714 NCORED30_716
+  NCORED31_718 VDDC_30 VDDCE_30 VDDPE_30 VNWC_31 VPW_30 VSSE WL[0] WL[1]
+  sram464x144CCHD4
XMEM_L_COL_31 BL[0]_31 BL[1]_31 BL[2]_31 BL[3]_31 CORED00_752 CORED01_754
+  CORED10_756 CORED11_758 CORED20_760 CORED21_762 CORED30_764 CORED31_766
+  NBL[0]_31 NBL[1]_31 NBL[2]_31 NBL[3]_31 NCORED00_768 NCORED01_770
+  NCORED10_772 NCORED11_774 NCORED20_776 NCORED21_778 NCORED30_780
+  NCORED31_782 VDDC_31 VDDCE_31 VDDPE_31 VNWC_32 VPW_31 VSSE WL[0] WL[1]
+  sram464x144CCHD4
XMEM_L_COL_32 BL[0]_32 BL[1]_32 BL[2]_32 BL[3]_32 CORED00_816 CORED01_818
+  CORED10_820 CORED11_822 CORED20_824 CORED21_826 CORED30_828 CORED31_830
+  NBL[0]_32 NBL[1]_32 NBL[2]_32 NBL[3]_32 NCORED00_832 NCORED01_834
+  NCORED10_836 NCORED11_838 NCORED20_840 NCORED21_842 NCORED30_844
+  NCORED31_846 VDDC_32 VDDCE_32 VDDPE_32 VNWC_33 VPW_32 VSSE WL[0] WL[1]
+  sram464x144CCHD4
XMEM_L_COL_33 BL[0]_33 BL[1]_33 BL[2]_33 BL[3]_33 CORED00_880 CORED01_882
+  CORED10_884 CORED11_886 CORED20_888 CORED21_890 CORED30_892 CORED31_894
+  NBL[0]_33 NBL[1]_33 NBL[2]_33 NBL[3]_33 NCORED00_896 NCORED01_898
+  NCORED10_900 NCORED11_902 NCORED20_904 NCORED21_906 NCORED30_908
+  NCORED31_910 VDDC_33 VDDCE_33 VDDPE_33 VNWC_34 VPW_33 VSSE WL[0] WL[1]
+  sram464x144CCHD4
XMEM_L_COL_34 BL[0]_34 BL[1]_34 BL[2]_34 BL[3]_34 CORED00_944 CORED01_946
+  CORED10_948 CORED11_950 CORED20_952 CORED21_954 CORED30_956 CORED31_958
+  NBL[0]_34 NBL[1]_34 NBL[2]_34 NBL[3]_34 NCORED00_960 NCORED01_962
+  NCORED10_964 NCORED11_966 NCORED20_968 NCORED21_970 NCORED30_972
+  NCORED31_974 VDDC_34 VDDCE_34 VDDPE_34 VNWC_35 VPW_34 VSSE WL[0] WL[1]
+  sram464x144CCHD4
XMEM_L_COL_35 BL[0]_35 BL[1]_35 BL[2]_35 BL[3]_35 CORED00_1008 CORED01_1010
+  CORED10_1012 CORED11_1014 CORED20_1016 CORED21_1018 CORED30_1020
+  CORED31_1022 NBL[0]_35 NBL[1]_35 NBL[2]_35 NBL[3]_35 NCORED00_1024
+  NCORED01_1026 NCORED10_1028 NCORED11_1030 NCORED20_1032 NCORED21_1034
+  NCORED30_1036 NCORED31_1038 VDDC_35 VDDCE_35 VDDPE_35 VNWC_36 VPW_35 VSSE
+  WL[0] WL[1] sram464x144CCHD4
XMEM_L_COL_4 BL[0]_4 BL[1]_4 BL[2]_4 BL[3]_4 CORED00_432 CORED01_434
+  CORED10_436 CORED11_438 CORED20_440 CORED21_442 CORED30_444 CORED31_446
+  NBL[0]_4 NBL[1]_4 NBL[2]_4 NBL[3]_4 NCORED00_448 NCORED01_450 NCORED10_452
+  NCORED11_454 NCORED20_456 NCORED21_458 NCORED30_460 NCORED31_462 VDDC_4
+  VDDCE_4 VDDPE_4 VNWC_5 VPW_4 VSSE WL[0] WL[1] sram464x144CCHD4
XMEM_L_COL_5 BL[0]_5 BL[1]_5 BL[2]_5 BL[3]_5 CORED00_464 CORED01_466
+  CORED10_468 CORED11_470 CORED20_472 CORED21_474 CORED30_476 CORED31_478
+  NBL[0]_5 NBL[1]_5 NBL[2]_5 NBL[3]_5 NCORED00_480 NCORED01_482 NCORED10_484
+  NCORED11_486 NCORED20_488 NCORED21_490 NCORED30_492 NCORED31_494 VDDC_5
+  VDDCE_5 VDDPE_5 VNWC_6 VPW_5 VSSE WL[0] WL[1] sram464x144CCHD4
XMEM_L_COL_6 BL[0]_6 BL[1]_6 BL[2]_6 BL[3]_6 CORED00_496 CORED01_498
+  CORED10_500 CORED11_502 CORED20_504 CORED21_506 CORED30_508 CORED31_510
+  NBL[0]_6 NBL[1]_6 NBL[2]_6 NBL[3]_6 NCORED00_512 NCORED01_514 NCORED10_516
+  NCORED11_518 NCORED20_520 NCORED21_522 NCORED30_524 NCORED31_526 VDDC_6
+  VDDCE_6 VDDPE_6 VNWC_7 VPW_6 VSSE WL[0] WL[1] sram464x144CCHD4
XMEM_L_COL_7 BL[0]_7 BL[1]_7 BL[2]_7 BL[3]_7 CORED00_528 CORED01_530
+  CORED10_532 CORED11_534 CORED20_536 CORED21_538 CORED30_540 CORED31_542
+  NBL[0]_7 NBL[1]_7 NBL[2]_7 NBL[3]_7 NCORED00_544 NCORED01_546 NCORED10_548
+  NCORED11_550 NCORED20_552 NCORED21_554 NCORED30_556 NCORED31_558 VDDC_7
+  VDDCE_7 VDDPE_7 VNWC_8 VPW_7 VSSE WL[0] WL[1] sram464x144CCHD4
XMEM_L_COL_8 BL[0]_8 BL[1]_8 BL[2]_8 BL[3]_8 CORED00_560 CORED01_562
+  CORED10_564 CORED11_566 CORED20_568 CORED21_570 CORED30_572 CORED31_574
+  NBL[0]_8 NBL[1]_8 NBL[2]_8 NBL[3]_8 NCORED00_576 NCORED01_578 NCORED10_580
+  NCORED11_582 NCORED20_584 NCORED21_586 NCORED30_588 NCORED31_590 VDDC_8
+  VDDCE_8 VDDPE_8 VNWC_9 VPW_8 VSSE WL[0] WL[1] sram464x144CCHD4
XMEM_L_COL_9 BL[0]_9 BL[1]_9 BL[2]_9 BL[3]_9 CORED00_592 CORED01_594
+  CORED10_596 CORED11_598 CORED20_600 CORED21_602 CORED30_604 CORED31_606
+  NBL[0]_9 NBL[1]_9 NBL[2]_9 NBL[3]_9 NCORED00_608 NCORED01_610 NCORED10_612
+  NCORED11_614 NCORED20_616 NCORED21_618 NCORED30_620 NCORED31_622 VDDC_9
+  VDDCE_9 VDDPE_9 VNWC_10 VPW_9 VSSE WL[0] WL[1] sram464x144CCHD4
XMEM_L_COL_EDGEL VNWC_0 VNWP_0 VSSE VSSE WL[0] WL[1] sram464x144CCHD4_EDG
XMEM_L_COL_EDGER VNWC_37 VNWP_1 VSSE VSSE WL[0] WL[1] sram464x144CCHD4WD_EDG
.ENDS sram464x144MEM_L_MIDT_ROW
****
.SUBCKT sram464x144CCHD4WD_CORNER VDDC VNWC VNWP VPW VSSE
** sram464x144CCHD4WD_CORNER: 3 flat devices **
X_MXN0 VSSE NET19 NET18 VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MXN2 VPW NET15 NET14 VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MXN3 VPW NET23 VPW VPW dslnfetpd_ckt W=0.142U L=0.055U
.ENDS sram464x144CCHD4WD_CORNER
****
.SUBCKT sram464x144MEM_SLICE_CAP_L BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4
+  BL[0]_5 BL[0]_6 BL[0]_7 BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13
+  BL[0]_14 BL[0]_15 BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21
+  BL[0]_22 BL[0]_23 BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29
+  BL[0]_30 BL[0]_31 BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1
+  BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10
+  BL[1]_11 BL[1]_12 BL[1]_13 BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18
+  BL[1]_19 BL[1]_20 BL[1]_21 BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26
+  BL[1]_27 BL[1]_28 BL[1]_29 BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34
+  BL[1]_35 BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7
+  BL[2]_8 BL[2]_9 BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15
+  BL[2]_16 BL[2]_17 BL[2]_18 BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23
+  BL[2]_24 BL[2]_25 BL[2]_26 BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31
+  BL[2]_32 BL[2]_33 BL[2]_34 BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4
+  BL[3]_5 BL[3]_6 BL[3]_7 BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13
+  BL[3]_14 BL[3]_15 BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21
+  BL[3]_22 BL[3]_23 BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29
+  BL[3]_30 BL[3]_31 BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1
+  NBL[0]_2 NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9
+  NBL[0]_10 NBL[0]_11 NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16
+  NBL[0]_17 NBL[0]_18 NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23
+  NBL[0]_24 NBL[0]_25 NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30
+  NBL[0]_31 NBL[0]_32 NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1
+  NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9
+  NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16
+  NBL[1]_17 NBL[1]_18 NBL[1]_19 NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23
+  NBL[1]_24 NBL[1]_25 NBL[1]_26 NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30
+  NBL[1]_31 NBL[1]_32 NBL[1]_33 NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1
+  NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9
+  NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13 NBL[2]_14 NBL[2]_15 NBL[2]_16
+  NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20 NBL[2]_21 NBL[2]_22 NBL[2]_23
+  NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27 NBL[2]_28 NBL[2]_29 NBL[2]_30
+  NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34 NBL[2]_35 NBL[3]_0 NBL[3]_1
+  NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 NBL[3]_8 NBL[3]_9
+  NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13 NBL[3]_14 NBL[3]_15 NBL[3]_16
+  NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20 NBL[3]_21 NBL[3]_22 NBL[3]_23
+  NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27 NBL[3]_28 NBL[3]_29 NBL[3]_30
+  NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34 NBL[3]_35 VDDC VDDPE_0 VDDPE_1
+  VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8 VDDPE_9 VDDPE_10
+  VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16 VDDPE_17 VDDPE_18
+  VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24 VDDPE_25 VDDPE_26
+  VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32 VDDPE_33 VDDPE_34
+  VDDPE_35 VNWP_0 VNWP_1 VSSE
** sram464x144MEM_SLICE_CAP_L: 1158 flat devices **
XTOP_EDGE_ROW0 BL[0]_0 BL[1]_0 BL[2]_0 BL[3]_0 NBL[0]_0 NBL[1]_0 NBL[2]_0
+  NBL[3]_0 VDDC VDDC VDDPE_0 VDDC VSSE VSSE sram464x144CCHD4_TOPBOT
XTOP_EDGE_ROW1 BL[0]_1 BL[1]_1 BL[2]_1 BL[3]_1 NBL[0]_1 NBL[1]_1 NBL[2]_1
+  NBL[3]_1 VDDC VDDC VDDPE_1 VDDC VSSE VSSE sram464x144CCHD4_TOPBOT
XTOP_EDGE_ROW10 BL[0]_10 BL[1]_10 BL[2]_10 BL[3]_10 NBL[0]_10 NBL[1]_10
+  NBL[2]_10 NBL[3]_10 VDDC VDDC VDDPE_10 VDDC VSSE VSSE
+  sram464x144CCHD4_TOPBOT
XTOP_EDGE_ROW11 BL[0]_11 BL[1]_11 BL[2]_11 BL[3]_11 NBL[0]_11 NBL[1]_11
+  NBL[2]_11 NBL[3]_11 VDDC VDDC VDDPE_11 VDDC VSSE VSSE
+  sram464x144CCHD4_TOPBOT
XTOP_EDGE_ROW12 BL[0]_12 BL[1]_12 BL[2]_12 BL[3]_12 NBL[0]_12 NBL[1]_12
+  NBL[2]_12 NBL[3]_12 VDDC VDDC VDDPE_12 VDDC VSSE VSSE
+  sram464x144CCHD4_TOPBOT
XTOP_EDGE_ROW13 BL[0]_13 BL[1]_13 BL[2]_13 BL[3]_13 NBL[0]_13 NBL[1]_13
+  NBL[2]_13 NBL[3]_13 VDDC VDDC VDDPE_13 VDDC VSSE VSSE
+  sram464x144CCHD4_TOPBOT
XTOP_EDGE_ROW14 BL[0]_14 BL[1]_14 BL[2]_14 BL[3]_14 NBL[0]_14 NBL[1]_14
+  NBL[2]_14 NBL[3]_14 VDDC VDDC VDDPE_14 VDDC VSSE VSSE
+  sram464x144CCHD4_TOPBOT
XTOP_EDGE_ROW15 BL[0]_15 BL[1]_15 BL[2]_15 BL[3]_15 NBL[0]_15 NBL[1]_15
+  NBL[2]_15 NBL[3]_15 VDDC VDDC VDDPE_15 VDDC VSSE VSSE
+  sram464x144CCHD4_TOPBOT
XTOP_EDGE_ROW16 BL[0]_16 BL[1]_16 BL[2]_16 BL[3]_16 NBL[0]_16 NBL[1]_16
+  NBL[2]_16 NBL[3]_16 VDDC VDDC VDDPE_16 VDDC VSSE VSSE
+  sram464x144CCHD4_TOPBOT
XTOP_EDGE_ROW17 BL[0]_17 BL[1]_17 BL[2]_17 BL[3]_17 NBL[0]_17 NBL[1]_17
+  NBL[2]_17 NBL[3]_17 VDDC VDDC VDDPE_17 VDDC VSSE VSSE
+  sram464x144CCHD4_TOPBOT
XTOP_EDGE_ROW18 BL[0]_18 BL[1]_18 BL[2]_18 BL[3]_18 NBL[0]_18 NBL[1]_18
+  NBL[2]_18 NBL[3]_18 VDDC VDDC VDDPE_18 VDDC VSSE VSSE
+  sram464x144CCHD4_TOPBOT
XTOP_EDGE_ROW19 BL[0]_19 BL[1]_19 BL[2]_19 BL[3]_19 NBL[0]_19 NBL[1]_19
+  NBL[2]_19 NBL[3]_19 VDDC VDDC VDDPE_19 VDDC VSSE VSSE
+  sram464x144CCHD4_TOPBOT
XTOP_EDGE_ROW2 BL[0]_2 BL[1]_2 BL[2]_2 BL[3]_2 NBL[0]_2 NBL[1]_2 NBL[2]_2
+  NBL[3]_2 VDDC VDDC VDDPE_2 VDDC VSSE VSSE sram464x144CCHD4_TOPBOT
XTOP_EDGE_ROW20 BL[0]_20 BL[1]_20 BL[2]_20 BL[3]_20 NBL[0]_20 NBL[1]_20
+  NBL[2]_20 NBL[3]_20 VDDC VDDC VDDPE_20 VDDC VSSE VSSE
+  sram464x144CCHD4_TOPBOT
XTOP_EDGE_ROW21 BL[0]_21 BL[1]_21 BL[2]_21 BL[3]_21 NBL[0]_21 NBL[1]_21
+  NBL[2]_21 NBL[3]_21 VDDC VDDC VDDPE_21 VDDC VSSE VSSE
+  sram464x144CCHD4_TOPBOT
XTOP_EDGE_ROW22 BL[0]_22 BL[1]_22 BL[2]_22 BL[3]_22 NBL[0]_22 NBL[1]_22
+  NBL[2]_22 NBL[3]_22 VDDC VDDC VDDPE_22 VDDC VSSE VSSE
+  sram464x144CCHD4_TOPBOT
XTOP_EDGE_ROW23 BL[0]_23 BL[1]_23 BL[2]_23 BL[3]_23 NBL[0]_23 NBL[1]_23
+  NBL[2]_23 NBL[3]_23 VDDC VDDC VDDPE_23 VDDC VSSE VSSE
+  sram464x144CCHD4_TOPBOT
XTOP_EDGE_ROW24 BL[0]_24 BL[1]_24 BL[2]_24 BL[3]_24 NBL[0]_24 NBL[1]_24
+  NBL[2]_24 NBL[3]_24 VDDC VDDC VDDPE_24 VDDC VSSE VSSE
+  sram464x144CCHD4_TOPBOT
XTOP_EDGE_ROW25 BL[0]_25 BL[1]_25 BL[2]_25 BL[3]_25 NBL[0]_25 NBL[1]_25
+  NBL[2]_25 NBL[3]_25 VDDC VDDC VDDPE_25 VDDC VSSE VSSE
+  sram464x144CCHD4_TOPBOT
XTOP_EDGE_ROW26 BL[0]_26 BL[1]_26 BL[2]_26 BL[3]_26 NBL[0]_26 NBL[1]_26
+  NBL[2]_26 NBL[3]_26 VDDC VDDC VDDPE_26 VDDC VSSE VSSE
+  sram464x144CCHD4_TOPBOT
XTOP_EDGE_ROW27 BL[0]_27 BL[1]_27 BL[2]_27 BL[3]_27 NBL[0]_27 NBL[1]_27
+  NBL[2]_27 NBL[3]_27 VDDC VDDC VDDPE_27 VDDC VSSE VSSE
+  sram464x144CCHD4_TOPBOT
XTOP_EDGE_ROW28 BL[0]_28 BL[1]_28 BL[2]_28 BL[3]_28 NBL[0]_28 NBL[1]_28
+  NBL[2]_28 NBL[3]_28 VDDC VDDC VDDPE_28 VDDC VSSE VSSE
+  sram464x144CCHD4_TOPBOT
XTOP_EDGE_ROW29 BL[0]_29 BL[1]_29 BL[2]_29 BL[3]_29 NBL[0]_29 NBL[1]_29
+  NBL[2]_29 NBL[3]_29 VDDC VDDC VDDPE_29 VDDC VSSE VSSE
+  sram464x144CCHD4_TOPBOT
XTOP_EDGE_ROW3 BL[0]_3 BL[1]_3 BL[2]_3 BL[3]_3 NBL[0]_3 NBL[1]_3 NBL[2]_3
+  NBL[3]_3 VDDC VDDC VDDPE_3 VDDC VSSE VSSE sram464x144CCHD4_TOPBOT
XTOP_EDGE_ROW30 BL[0]_30 BL[1]_30 BL[2]_30 BL[3]_30 NBL[0]_30 NBL[1]_30
+  NBL[2]_30 NBL[3]_30 VDDC VDDC VDDPE_30 VDDC VSSE VSSE
+  sram464x144CCHD4_TOPBOT
XTOP_EDGE_ROW31 BL[0]_31 BL[1]_31 BL[2]_31 BL[3]_31 NBL[0]_31 NBL[1]_31
+  NBL[2]_31 NBL[3]_31 VDDC VDDC VDDPE_31 VDDC VSSE VSSE
+  sram464x144CCHD4_TOPBOT
XTOP_EDGE_ROW32 BL[0]_32 BL[1]_32 BL[2]_32 BL[3]_32 NBL[0]_32 NBL[1]_32
+  NBL[2]_32 NBL[3]_32 VDDC VDDC VDDPE_32 VDDC VSSE VSSE
+  sram464x144CCHD4_TOPBOT
XTOP_EDGE_ROW33 BL[0]_33 BL[1]_33 BL[2]_33 BL[3]_33 NBL[0]_33 NBL[1]_33
+  NBL[2]_33 NBL[3]_33 VDDC VDDC VDDPE_33 VDDC VSSE VSSE
+  sram464x144CCHD4_TOPBOT
XTOP_EDGE_ROW34 BL[0]_34 BL[1]_34 BL[2]_34 BL[3]_34 NBL[0]_34 NBL[1]_34
+  NBL[2]_34 NBL[3]_34 VDDC VDDC VDDPE_34 VDDC VSSE VSSE
+  sram464x144CCHD4_TOPBOT
XTOP_EDGE_ROW35 BL[0]_35 BL[1]_35 BL[2]_35 BL[3]_35 NBL[0]_35 NBL[1]_35
+  NBL[2]_35 NBL[3]_35 VDDC VDDC VDDPE_35 VDDC VSSE VSSE
+  sram464x144CCHD4_TOPBOT
XTOP_EDGE_ROW4 BL[0]_4 BL[1]_4 BL[2]_4 BL[3]_4 NBL[0]_4 NBL[1]_4 NBL[2]_4
+  NBL[3]_4 VDDC VDDC VDDPE_4 VDDC VSSE VSSE sram464x144CCHD4_TOPBOT
XTOP_EDGE_ROW5 BL[0]_5 BL[1]_5 BL[2]_5 BL[3]_5 NBL[0]_5 NBL[1]_5 NBL[2]_5
+  NBL[3]_5 VDDC VDDC VDDPE_5 VDDC VSSE VSSE sram464x144CCHD4_TOPBOT
XTOP_EDGE_ROW6 BL[0]_6 BL[1]_6 BL[2]_6 BL[3]_6 NBL[0]_6 NBL[1]_6 NBL[2]_6
+  NBL[3]_6 VDDC VDDC VDDPE_6 VDDC VSSE VSSE sram464x144CCHD4_TOPBOT
XTOP_EDGE_ROW7 BL[0]_7 BL[1]_7 BL[2]_7 BL[3]_7 NBL[0]_7 NBL[1]_7 NBL[2]_7
+  NBL[3]_7 VDDC VDDC VDDPE_7 VDDC VSSE VSSE sram464x144CCHD4_TOPBOT
XTOP_EDGE_ROW8 BL[0]_8 BL[1]_8 BL[2]_8 BL[3]_8 NBL[0]_8 NBL[1]_8 NBL[2]_8
+  NBL[3]_8 VDDC VDDC VDDPE_8 VDDC VSSE VSSE sram464x144CCHD4_TOPBOT
XTOP_EDGE_ROW9 BL[0]_9 BL[1]_9 BL[2]_9 BL[3]_9 NBL[0]_9 NBL[1]_9 NBL[2]_9
+  NBL[3]_9 VDDC VDDC VDDPE_9 VDDC VSSE VSSE sram464x144CCHD4_TOPBOT
XTOP_EDGE_ROWEDGEL VDDC VDDC VNWP_0 VSSE VSSE sram464x144CCHD4_CORNER
XTOP_EDGE_ROWEDGER VDDC VDDC VNWP_1 VSSE VSSE sram464x144CCHD4WD_CORNER
.ENDS sram464x144MEM_SLICE_CAP_L
****
.SUBCKT sram464x144MEM_L_MID_ROW BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4
+  BL[0]_5 BL[0]_6 BL[0]_7 BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13
+  BL[0]_14 BL[0]_15 BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21
+  BL[0]_22 BL[0]_23 BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29
+  BL[0]_30 BL[0]_31 BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1
+  BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10
+  BL[1]_11 BL[1]_12 BL[1]_13 BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18
+  BL[1]_19 BL[1]_20 BL[1]_21 BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26
+  BL[1]_27 BL[1]_28 BL[1]_29 BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34
+  BL[1]_35 BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7
+  BL[2]_8 BL[2]_9 BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15
+  BL[2]_16 BL[2]_17 BL[2]_18 BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23
+  BL[2]_24 BL[2]_25 BL[2]_26 BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31
+  BL[2]_32 BL[2]_33 BL[2]_34 BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4
+  BL[3]_5 BL[3]_6 BL[3]_7 BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13
+  BL[3]_14 BL[3]_15 BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21
+  BL[3]_22 BL[3]_23 BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29
+  BL[3]_30 BL[3]_31 BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1
+  NBL[0]_2 NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9
+  NBL[0]_10 NBL[0]_11 NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16
+  NBL[0]_17 NBL[0]_18 NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23
+  NBL[0]_24 NBL[0]_25 NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30
+  NBL[0]_31 NBL[0]_32 NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1
+  NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9
+  NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16
+  NBL[1]_17 NBL[1]_18 NBL[1]_19 NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23
+  NBL[1]_24 NBL[1]_25 NBL[1]_26 NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30
+  NBL[1]_31 NBL[1]_32 NBL[1]_33 NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1
+  NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9
+  NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13 NBL[2]_14 NBL[2]_15 NBL[2]_16
+  NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20 NBL[2]_21 NBL[2]_22 NBL[2]_23
+  NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27 NBL[2]_28 NBL[2]_29 NBL[2]_30
+  NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34 NBL[2]_35 NBL[3]_0 NBL[3]_1
+  NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 NBL[3]_8 NBL[3]_9
+  NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13 NBL[3]_14 NBL[3]_15 NBL[3]_16
+  NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20 NBL[3]_21 NBL[3]_22 NBL[3]_23
+  NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27 NBL[3]_28 NBL[3]_29 NBL[3]_30
+  NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34 NBL[3]_35 VDDCE_0 VDDCE_1 VDDCE_2
+  VDDCE_3 VDDCE_4 VDDCE_5 VDDCE_6 VDDCE_7 VDDCE_8 VDDCE_9 VDDCE_10 VDDCE_11
+  VDDCE_12 VDDCE_13 VDDCE_14 VDDCE_15 VDDCE_16 VDDCE_17 VDDCE_18 VDDCE_19
+  VDDCE_20 VDDCE_21 VDDCE_22 VDDCE_23 VDDCE_24 VDDCE_25 VDDCE_26 VDDCE_27
+  VDDCE_28 VDDCE_29 VDDCE_30 VDDCE_31 VDDCE_32 VDDCE_33 VDDCE_34 VDDCE_35
+  VDDC_0 VDDC_1 VDDC_2 VDDC_3 VDDC_4 VDDC_5 VDDC_6 VDDC_7 VDDC_8 VDDC_9
+  VDDC_10 VDDC_11 VDDC_12 VDDC_13 VDDC_14 VDDC_15 VDDC_16 VDDC_17 VDDC_18
+  VDDC_19 VDDC_20 VDDC_21 VDDC_22 VDDC_23 VDDC_24 VDDC_25 VDDC_26 VDDC_27
+  VDDC_28 VDDC_29 VDDC_30 VDDC_31 VDDC_32 VDDC_33 VDDC_34 VDDC_35 VDDPE_0
+  VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8 VDDPE_9
+  VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16 VDDPE_17
+  VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24 VDDPE_25
+  VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32 VDDPE_33
+  VDDPE_34 VDDPE_35 VNWC_0 VNWC_1 VNWC_2 VNWC_3 VNWC_4 VNWC_5 VNWC_6 VNWC_7
+  VNWC_8 VNWC_9 VNWC_10 VNWC_11 VNWC_12 VNWC_13 VNWC_14 VNWC_15 VNWC_16
+  VNWC_17 VNWC_18 VNWC_19 VNWC_20 VNWC_21 VNWC_22 VNWC_23 VNWC_24 VNWC_25
+  VNWC_26 VNWC_27 VNWC_28 VNWC_29 VNWC_30 VNWC_31 VNWC_32 VNWC_33 VNWC_34
+  VNWC_35 VNWC_36 VNWC_37 VNWP_0 VNWP_1 VPW_0 VPW_1 VPW_2 VPW_3 VPW_4 VPW_5
+  VPW_6 VPW_7 VPW_8 VPW_9 VPW_10 VPW_11 VPW_12 VPW_13 VPW_14 VPW_15 VPW_16
+  VPW_17 VPW_18 VPW_19 VPW_20 VPW_21 VPW_22 VPW_23 VPW_24 VPW_25 VPW_26
+  VPW_27 VPW_28 VPW_29 VPW_30 VPW_31 VPW_32 VPW_33 VPW_34 VPW_35 VSSE WL[0]
+  WL[1]
** sram464x144MEM_L_MID_ROW: 1732 flat devices **
XMEM_L_COL_0 BL[0]_0 BL[1]_0 BL[2]_0 BL[3]_0 CORED00_304 CORED01_306
+  CORED10_308 CORED11_310 CORED20_312 CORED21_314 CORED30_316 CORED31_318
+  NBL[0]_0 NBL[1]_0 NBL[2]_0 NBL[3]_0 NCORED00_320 NCORED01_322 NCORED10_324
+  NCORED11_326 NCORED20_328 NCORED21_330 NCORED30_332 NCORED31_334 VDDC_0
+  VDDCE_0 VDDPE_0 VNWC_1 VPW_0 VSSE WL[0] WL[1] sram464x144CCHD4
XMEM_L_COL_1 BL[0]_1 BL[1]_1 BL[2]_1 BL[3]_1 CORED00_336 CORED01_338
+  CORED10_340 CORED11_342 CORED20_344 CORED21_346 CORED30_348 CORED31_350
+  NBL[0]_1 NBL[1]_1 NBL[2]_1 NBL[3]_1 NCORED00_352 NCORED01_354 NCORED10_356
+  NCORED11_358 NCORED20_360 NCORED21_362 NCORED30_364 NCORED31_366 VDDC_1
+  VDDCE_1 VDDPE_1 VNWC_2 VPW_1 VSSE WL[0] WL[1] sram464x144CCHD4
XMEM_L_COL_10 BL[0]_10 BL[1]_10 BL[2]_10 BL[3]_10 CORED00_624 CORED01_626
+  CORED10_628 CORED11_630 CORED20_632 CORED21_634 CORED30_636 CORED31_638
+  NBL[0]_10 NBL[1]_10 NBL[2]_10 NBL[3]_10 NCORED00_640 NCORED01_642
+  NCORED10_644 NCORED11_646 NCORED20_648 NCORED21_650 NCORED30_652
+  NCORED31_654 VDDC_10 VDDCE_10 VDDPE_10 VNWC_11 VPW_10 VSSE WL[0] WL[1]
+  sram464x144CCHD4
XMEM_L_COL_11 BL[0]_11 BL[1]_11 BL[2]_11 BL[3]_11 CORED00_656 CORED01_658
+  CORED10_660 CORED11_662 CORED20_664 CORED21_666 CORED30_668 CORED31_670
+  NBL[0]_11 NBL[1]_11 NBL[2]_11 NBL[3]_11 NCORED00_672 NCORED01_674
+  NCORED10_676 NCORED11_678 NCORED20_680 NCORED21_682 NCORED30_684
+  NCORED31_686 VDDC_11 VDDCE_11 VDDPE_11 VNWC_12 VPW_11 VSSE WL[0] WL[1]
+  sram464x144CCHD4
XMEM_L_COL_12 BL[0]_12 BL[1]_12 BL[2]_12 BL[3]_12 CORED00_720 CORED01_722
+  CORED10_724 CORED11_726 CORED20_728 CORED21_730 CORED30_732 CORED31_734
+  NBL[0]_12 NBL[1]_12 NBL[2]_12 NBL[3]_12 NCORED00_736 NCORED01_738
+  NCORED10_740 NCORED11_742 NCORED20_744 NCORED21_746 NCORED30_748
+  NCORED31_750 VDDC_12 VDDCE_12 VDDPE_12 VNWC_13 VPW_12 VSSE WL[0] WL[1]
+  sram464x144CCHD4
XMEM_L_COL_13 BL[0]_13 BL[1]_13 BL[2]_13 BL[3]_13 CORED00_784 CORED01_786
+  CORED10_788 CORED11_790 CORED20_792 CORED21_794 CORED30_796 CORED31_798
+  NBL[0]_13 NBL[1]_13 NBL[2]_13 NBL[3]_13 NCORED00_800 NCORED01_802
+  NCORED10_804 NCORED11_806 NCORED20_808 NCORED21_810 NCORED30_812
+  NCORED31_814 VDDC_13 VDDCE_13 VDDPE_13 VNWC_14 VPW_13 VSSE WL[0] WL[1]
+  sram464x144CCHD4
XMEM_L_COL_14 BL[0]_14 BL[1]_14 BL[2]_14 BL[3]_14 CORED00_848 CORED01_850
+  CORED10_852 CORED11_854 CORED20_856 CORED21_858 CORED30_860 CORED31_862
+  NBL[0]_14 NBL[1]_14 NBL[2]_14 NBL[3]_14 NCORED00_864 NCORED01_866
+  NCORED10_868 NCORED11_870 NCORED20_872 NCORED21_874 NCORED30_876
+  NCORED31_878 VDDC_14 VDDCE_14 VDDPE_14 VNWC_15 VPW_14 VSSE WL[0] WL[1]
+  sram464x144CCHD4
XMEM_L_COL_15 BL[0]_15 BL[1]_15 BL[2]_15 BL[3]_15 CORED00_912 CORED01_914
+  CORED10_916 CORED11_918 CORED20_920 CORED21_922 CORED30_924 CORED31_926
+  NBL[0]_15 NBL[1]_15 NBL[2]_15 NBL[3]_15 NCORED00_928 NCORED01_930
+  NCORED10_932 NCORED11_934 NCORED20_936 NCORED21_938 NCORED30_940
+  NCORED31_942 VDDC_15 VDDCE_15 VDDPE_15 VNWC_16 VPW_15 VSSE WL[0] WL[1]
+  sram464x144CCHD4
XMEM_L_COL_16 BL[0]_16 BL[1]_16 BL[2]_16 BL[3]_16 CORED00_976 CORED01_978
+  CORED10_980 CORED11_982 CORED20_984 CORED21_986 CORED30_988 CORED31_990
+  NBL[0]_16 NBL[1]_16 NBL[2]_16 NBL[3]_16 NCORED00_992 NCORED01_994
+  NCORED10_996 NCORED11_998 NCORED20_1000 NCORED21_1002 NCORED30_1004
+  NCORED31_1006 VDDC_16 VDDCE_16 VDDPE_16 VNWC_17 VPW_16 VSSE WL[0] WL[1]
+  sram464x144CCHD4
XMEM_L_COL_17 BL[0]_17 BL[1]_17 BL[2]_17 BL[3]_17 CORED00_1040 CORED01_1042
+  CORED10_1044 CORED11_1046 CORED20_1048 CORED21_1050 CORED30_1052
+  CORED31_1054 NBL[0]_17 NBL[1]_17 NBL[2]_17 NBL[3]_17 NCORED00_1056
+  NCORED01_1058 NCORED10_1060 NCORED11_1062 NCORED20_1064 NCORED21_1066
+  NCORED30_1068 NCORED31_1070 VDDC_17 VDDCE_17 VDDPE_17 VNWC_18 VPW_17 VSSE
+  WL[0] WL[1] sram464x144CCHD4
XMEM_L_COL_18 BL[0]_18 BL[1]_18 BL[2]_18 BL[3]_18 CORED00_1072 CORED01_1074
+  CORED10_1076 CORED11_1078 CORED20_1080 CORED21_1082 CORED30_1084
+  CORED31_1086 NBL[0]_18 NBL[1]_18 NBL[2]_18 NBL[3]_18 NCORED00_1088
+  NCORED01_1090 NCORED10_1092 NCORED11_1094 NCORED20_1096 NCORED21_1098
+  NCORED30_1100 NCORED31_1102 VDDC_18 VDDCE_18 VDDPE_18 VNWC_19 VPW_18 VSSE
+  WL[0] WL[1] sram464x144CCHD4
XMEM_L_COL_19 BL[0]_19 BL[1]_19 BL[2]_19 BL[3]_19 CORED00_1104 CORED01_1106
+  CORED10_1108 CORED11_1110 CORED20_1112 CORED21_1114 CORED30_1116
+  CORED31_1118 NBL[0]_19 NBL[1]_19 NBL[2]_19 NBL[3]_19 NCORED00_1120
+  NCORED01_1122 NCORED10_1124 NCORED11_1126 NCORED20_1128 NCORED21_1130
+  NCORED30_1132 NCORED31_1134 VDDC_19 VDDCE_19 VDDPE_19 VNWC_20 VPW_19 VSSE
+  WL[0] WL[1] sram464x144CCHD4
XMEM_L_COL_2 BL[0]_2 BL[1]_2 BL[2]_2 BL[3]_2 CORED00_368 CORED01_370
+  CORED10_372 CORED11_374 CORED20_376 CORED21_378 CORED30_380 CORED31_382
+  NBL[0]_2 NBL[1]_2 NBL[2]_2 NBL[3]_2 NCORED00_384 NCORED01_386 NCORED10_388
+  NCORED11_390 NCORED20_392 NCORED21_394 NCORED30_396 NCORED31_398 VDDC_2
+  VDDCE_2 VDDPE_2 VNWC_3 VPW_2 VSSE WL[0] WL[1] sram464x144CCHD4
XMEM_L_COL_20 BL[0]_20 BL[1]_20 BL[2]_20 BL[3]_20 CORED00 CORED01 CORED10
+  CORED11 CORED20 CORED21 CORED30 CORED31 NBL[0]_20 NBL[1]_20 NBL[2]_20
+  NBL[3]_20 NCORED00 NCORED01 NCORED10 NCORED11 NCORED20 NCORED21 NCORED30
+  NCORED31 VDDC_20 VDDCE_20 VDDPE_20 VNWC_21 VPW_20 VSSE WL[0] WL[1]
+  sram464x144CCHD4
XMEM_L_COL_21 BL[0]_21 BL[1]_21 BL[2]_21 BL[3]_21 CORED00_16 CORED01_18
+  CORED10_20 CORED11_22 CORED20_24 CORED21_26 CORED30_28 CORED31_30 NBL[0]_21
+  NBL[1]_21 NBL[2]_21 NBL[3]_21 NCORED00_32 NCORED01_34 NCORED10_36
+  NCORED11_38 NCORED20_40 NCORED21_42 NCORED30_44 NCORED31_46 VDDC_21
+  VDDCE_21 VDDPE_21 VNWC_22 VPW_21 VSSE WL[0] WL[1] sram464x144CCHD4
XMEM_L_COL_22 BL[0]_22 BL[1]_22 BL[2]_22 BL[3]_22 CORED00_48 CORED01_50
+  CORED10_52 CORED11_54 CORED20_56 CORED21_58 CORED30_60 CORED31_62 NBL[0]_22
+  NBL[1]_22 NBL[2]_22 NBL[3]_22 NCORED00_64 NCORED01_66 NCORED10_68
+  NCORED11_70 NCORED20_72 NCORED21_74 NCORED30_76 NCORED31_78 VDDC_22
+  VDDCE_22 VDDPE_22 VNWC_23 VPW_22 VSSE WL[0] WL[1] sram464x144CCHD4
XMEM_L_COL_23 BL[0]_23 BL[1]_23 BL[2]_23 BL[3]_23 CORED00_80 CORED01_82
+  CORED10_84 CORED11_86 CORED20_88 CORED21_90 CORED30_92 CORED31_94 NBL[0]_23
+  NBL[1]_23 NBL[2]_23 NBL[3]_23 NCORED00_96 NCORED01_98 NCORED10_100
+  NCORED11_102 NCORED20_104 NCORED21_106 NCORED30_108 NCORED31_110 VDDC_23
+  VDDCE_23 VDDPE_23 VNWC_24 VPW_23 VSSE WL[0] WL[1] sram464x144CCHD4
XMEM_L_COL_24 BL[0]_24 BL[1]_24 BL[2]_24 BL[3]_24 CORED00_112 CORED01_114
+  CORED10_116 CORED11_118 CORED20_120 CORED21_122 CORED30_124 CORED31_126
+  NBL[0]_24 NBL[1]_24 NBL[2]_24 NBL[3]_24 NCORED00_128 NCORED01_130
+  NCORED10_132 NCORED11_134 NCORED20_136 NCORED21_138 NCORED30_140
+  NCORED31_142 VDDC_24 VDDCE_24 VDDPE_24 VNWC_25 VPW_24 VSSE WL[0] WL[1]
+  sram464x144CCHD4
XMEM_L_COL_25 BL[0]_25 BL[1]_25 BL[2]_25 BL[3]_25 CORED00_144 CORED01_146
+  CORED10_148 CORED11_150 CORED20_152 CORED21_154 CORED30_156 CORED31_158
+  NBL[0]_25 NBL[1]_25 NBL[2]_25 NBL[3]_25 NCORED00_160 NCORED01_162
+  NCORED10_164 NCORED11_166 NCORED20_168 NCORED21_170 NCORED30_172
+  NCORED31_174 VDDC_25 VDDCE_25 VDDPE_25 VNWC_26 VPW_25 VSSE WL[0] WL[1]
+  sram464x144CCHD4
XMEM_L_COL_26 BL[0]_26 BL[1]_26 BL[2]_26 BL[3]_26 CORED00_176 CORED01_178
+  CORED10_180 CORED11_182 CORED20_184 CORED21_186 CORED30_188 CORED31_190
+  NBL[0]_26 NBL[1]_26 NBL[2]_26 NBL[3]_26 NCORED00_192 NCORED01_194
+  NCORED10_196 NCORED11_198 NCORED20_200 NCORED21_202 NCORED30_204
+  NCORED31_206 VDDC_26 VDDCE_26 VDDPE_26 VNWC_27 VPW_26 VSSE WL[0] WL[1]
+  sram464x144CCHD4
XMEM_L_COL_27 BL[0]_27 BL[1]_27 BL[2]_27 BL[3]_27 CORED00_208 CORED01_210
+  CORED10_212 CORED11_214 CORED20_216 CORED21_218 CORED30_220 CORED31_222
+  NBL[0]_27 NBL[1]_27 NBL[2]_27 NBL[3]_27 NCORED00_224 NCORED01_226
+  NCORED10_228 NCORED11_230 NCORED20_232 NCORED21_234 NCORED30_236
+  NCORED31_238 VDDC_27 VDDCE_27 VDDPE_27 VNWC_28 VPW_27 VSSE WL[0] WL[1]
+  sram464x144CCHD4
XMEM_L_COL_28 BL[0]_28 BL[1]_28 BL[2]_28 BL[3]_28 CORED00_240 CORED01_242
+  CORED10_244 CORED11_246 CORED20_248 CORED21_250 CORED30_252 CORED31_254
+  NBL[0]_28 NBL[1]_28 NBL[2]_28 NBL[3]_28 NCORED00_256 NCORED01_258
+  NCORED10_260 NCORED11_262 NCORED20_264 NCORED21_266 NCORED30_268
+  NCORED31_270 VDDC_28 VDDCE_28 VDDPE_28 VNWC_29 VPW_28 VSSE WL[0] WL[1]
+  sram464x144CCHD4
XMEM_L_COL_29 BL[0]_29 BL[1]_29 BL[2]_29 BL[3]_29 CORED00_272 CORED01_274
+  CORED10_276 CORED11_278 CORED20_280 CORED21_282 CORED30_284 CORED31_286
+  NBL[0]_29 NBL[1]_29 NBL[2]_29 NBL[3]_29 NCORED00_288 NCORED01_290
+  NCORED10_292 NCORED11_294 NCORED20_296 NCORED21_298 NCORED30_300
+  NCORED31_302 VDDC_29 VDDCE_29 VDDPE_29 VNWC_30 VPW_29 VSSE WL[0] WL[1]
+  sram464x144CCHD4
XMEM_L_COL_3 BL[0]_3 BL[1]_3 BL[2]_3 BL[3]_3 CORED00_400 CORED01_402
+  CORED10_404 CORED11_406 CORED20_408 CORED21_410 CORED30_412 CORED31_414
+  NBL[0]_3 NBL[1]_3 NBL[2]_3 NBL[3]_3 NCORED00_416 NCORED01_418 NCORED10_420
+  NCORED11_422 NCORED20_424 NCORED21_426 NCORED30_428 NCORED31_430 VDDC_3
+  VDDCE_3 VDDPE_3 VNWC_4 VPW_3 VSSE WL[0] WL[1] sram464x144CCHD4
XMEM_L_COL_30 BL[0]_30 BL[1]_30 BL[2]_30 BL[3]_30 CORED00_688 CORED01_690
+  CORED10_692 CORED11_694 CORED20_696 CORED21_698 CORED30_700 CORED31_702
+  NBL[0]_30 NBL[1]_30 NBL[2]_30 NBL[3]_30 NCORED00_704 NCORED01_706
+  NCORED10_708 NCORED11_710 NCORED20_712 NCORED21_714 NCORED30_716
+  NCORED31_718 VDDC_30 VDDCE_30 VDDPE_30 VNWC_31 VPW_30 VSSE WL[0] WL[1]
+  sram464x144CCHD4
XMEM_L_COL_31 BL[0]_31 BL[1]_31 BL[2]_31 BL[3]_31 CORED00_752 CORED01_754
+  CORED10_756 CORED11_758 CORED20_760 CORED21_762 CORED30_764 CORED31_766
+  NBL[0]_31 NBL[1]_31 NBL[2]_31 NBL[3]_31 NCORED00_768 NCORED01_770
+  NCORED10_772 NCORED11_774 NCORED20_776 NCORED21_778 NCORED30_780
+  NCORED31_782 VDDC_31 VDDCE_31 VDDPE_31 VNWC_32 VPW_31 VSSE WL[0] WL[1]
+  sram464x144CCHD4
XMEM_L_COL_32 BL[0]_32 BL[1]_32 BL[2]_32 BL[3]_32 CORED00_816 CORED01_818
+  CORED10_820 CORED11_822 CORED20_824 CORED21_826 CORED30_828 CORED31_830
+  NBL[0]_32 NBL[1]_32 NBL[2]_32 NBL[3]_32 NCORED00_832 NCORED01_834
+  NCORED10_836 NCORED11_838 NCORED20_840 NCORED21_842 NCORED30_844
+  NCORED31_846 VDDC_32 VDDCE_32 VDDPE_32 VNWC_33 VPW_32 VSSE WL[0] WL[1]
+  sram464x144CCHD4
XMEM_L_COL_33 BL[0]_33 BL[1]_33 BL[2]_33 BL[3]_33 CORED00_880 CORED01_882
+  CORED10_884 CORED11_886 CORED20_888 CORED21_890 CORED30_892 CORED31_894
+  NBL[0]_33 NBL[1]_33 NBL[2]_33 NBL[3]_33 NCORED00_896 NCORED01_898
+  NCORED10_900 NCORED11_902 NCORED20_904 NCORED21_906 NCORED30_908
+  NCORED31_910 VDDC_33 VDDCE_33 VDDPE_33 VNWC_34 VPW_33 VSSE WL[0] WL[1]
+  sram464x144CCHD4
XMEM_L_COL_34 BL[0]_34 BL[1]_34 BL[2]_34 BL[3]_34 CORED00_944 CORED01_946
+  CORED10_948 CORED11_950 CORED20_952 CORED21_954 CORED30_956 CORED31_958
+  NBL[0]_34 NBL[1]_34 NBL[2]_34 NBL[3]_34 NCORED00_960 NCORED01_962
+  NCORED10_964 NCORED11_966 NCORED20_968 NCORED21_970 NCORED30_972
+  NCORED31_974 VDDC_34 VDDCE_34 VDDPE_34 VNWC_35 VPW_34 VSSE WL[0] WL[1]
+  sram464x144CCHD4
XMEM_L_COL_35 BL[0]_35 BL[1]_35 BL[2]_35 BL[3]_35 CORED00_1008 CORED01_1010
+  CORED10_1012 CORED11_1014 CORED20_1016 CORED21_1018 CORED30_1020
+  CORED31_1022 NBL[0]_35 NBL[1]_35 NBL[2]_35 NBL[3]_35 NCORED00_1024
+  NCORED01_1026 NCORED10_1028 NCORED11_1030 NCORED20_1032 NCORED21_1034
+  NCORED30_1036 NCORED31_1038 VDDC_35 VDDCE_35 VDDPE_35 VNWC_36 VPW_35 VSSE
+  WL[0] WL[1] sram464x144CCHD4
XMEM_L_COL_4 BL[0]_4 BL[1]_4 BL[2]_4 BL[3]_4 CORED00_432 CORED01_434
+  CORED10_436 CORED11_438 CORED20_440 CORED21_442 CORED30_444 CORED31_446
+  NBL[0]_4 NBL[1]_4 NBL[2]_4 NBL[3]_4 NCORED00_448 NCORED01_450 NCORED10_452
+  NCORED11_454 NCORED20_456 NCORED21_458 NCORED30_460 NCORED31_462 VDDC_4
+  VDDCE_4 VDDPE_4 VNWC_5 VPW_4 VSSE WL[0] WL[1] sram464x144CCHD4
XMEM_L_COL_5 BL[0]_5 BL[1]_5 BL[2]_5 BL[3]_5 CORED00_464 CORED01_466
+  CORED10_468 CORED11_470 CORED20_472 CORED21_474 CORED30_476 CORED31_478
+  NBL[0]_5 NBL[1]_5 NBL[2]_5 NBL[3]_5 NCORED00_480 NCORED01_482 NCORED10_484
+  NCORED11_486 NCORED20_488 NCORED21_490 NCORED30_492 NCORED31_494 VDDC_5
+  VDDCE_5 VDDPE_5 VNWC_6 VPW_5 VSSE WL[0] WL[1] sram464x144CCHD4
XMEM_L_COL_6 BL[0]_6 BL[1]_6 BL[2]_6 BL[3]_6 CORED00_496 CORED01_498
+  CORED10_500 CORED11_502 CORED20_504 CORED21_506 CORED30_508 CORED31_510
+  NBL[0]_6 NBL[1]_6 NBL[2]_6 NBL[3]_6 NCORED00_512 NCORED01_514 NCORED10_516
+  NCORED11_518 NCORED20_520 NCORED21_522 NCORED30_524 NCORED31_526 VDDC_6
+  VDDCE_6 VDDPE_6 VNWC_7 VPW_6 VSSE WL[0] WL[1] sram464x144CCHD4
XMEM_L_COL_7 BL[0]_7 BL[1]_7 BL[2]_7 BL[3]_7 CORED00_528 CORED01_530
+  CORED10_532 CORED11_534 CORED20_536 CORED21_538 CORED30_540 CORED31_542
+  NBL[0]_7 NBL[1]_7 NBL[2]_7 NBL[3]_7 NCORED00_544 NCORED01_546 NCORED10_548
+  NCORED11_550 NCORED20_552 NCORED21_554 NCORED30_556 NCORED31_558 VDDC_7
+  VDDCE_7 VDDPE_7 VNWC_8 VPW_7 VSSE WL[0] WL[1] sram464x144CCHD4
XMEM_L_COL_8 BL[0]_8 BL[1]_8 BL[2]_8 BL[3]_8 CORED00_560 CORED01_562
+  CORED10_564 CORED11_566 CORED20_568 CORED21_570 CORED30_572 CORED31_574
+  NBL[0]_8 NBL[1]_8 NBL[2]_8 NBL[3]_8 NCORED00_576 NCORED01_578 NCORED10_580
+  NCORED11_582 NCORED20_584 NCORED21_586 NCORED30_588 NCORED31_590 VDDC_8
+  VDDCE_8 VDDPE_8 VNWC_9 VPW_8 VSSE WL[0] WL[1] sram464x144CCHD4
XMEM_L_COL_9 BL[0]_9 BL[1]_9 BL[2]_9 BL[3]_9 CORED00_592 CORED01_594
+  CORED10_596 CORED11_598 CORED20_600 CORED21_602 CORED30_604 CORED31_606
+  NBL[0]_9 NBL[1]_9 NBL[2]_9 NBL[3]_9 NCORED00_608 NCORED01_610 NCORED10_612
+  NCORED11_614 NCORED20_616 NCORED21_618 NCORED30_620 NCORED31_622 VDDC_9
+  VDDCE_9 VDDPE_9 VNWC_10 VPW_9 VSSE WL[0] WL[1] sram464x144CCHD4
XMEM_L_COL_EDGEL VNWC_0 VNWP_0 VSSE VSSE WL[0] WL[1] sram464x144CCHD4_EDG
XMEM_L_COL_EDGER VNWC_37 VNWP_1 VSSE VSSE WL[0] WL[1] sram464x144CCHD4WD_EDG
.ENDS sram464x144MEM_L_MID_ROW
****
.SUBCKT sram464x144CCHD4_EDG_STRAP VNWC VNWP VPW VSSE
** sram464x144CCHD4_EDG_STRAP: 2 flat devices **
X_MXN1 VSSE NET16 NET15 VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MXN3 VSSE NET12 NET11 VPW dslnfetpd_ckt W=0.142U L=0.055U
.ENDS sram464x144CCHD4_EDG_STRAP
****
.SUBCKT sram464x144CCHD4_STRAP BL[0] BL[1] BL[2] BL[3] NBL[0] NBL[1] NBL[2]
+  NBL[3] VDDC VDDCE VDDPE VNWC VPW VSSE
** sram464x144CCHD4_STRAP: 24 flat devices **
X_MXN36 VSSE NET96 NET107 VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MXN37 VSSE NET76 NET139 VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MXN38 NBL[2] VPW NET135 VPW dslnfetwl_ckt W=0.11U L=0.059U
X_MXN39 NBL[3] VPW NET159 VPW dslnfetwl_ckt W=0.11U L=0.059U
X_MXN40 NET130 VPW NBL[3] VPW dslnfetwl_ckt W=0.11U L=0.059U
X_MXN41 NBL[2] VPW NET127 VPW dslnfetwl_ckt W=0.11U L=0.059U
X_MXN42 VSSE NET100 NET151 VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MXN43 VSSE NET92 NET123 VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MXN44 VSSE NET88 NET163 VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MXN45 VSSE NET72 NET115 VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MXN46 NBL[0] VPW NET155 VPW dslnfetwl_ckt W=0.11U L=0.059U
X_MXN47 NET118 VPW NBL[1] VPW dslnfetwl_ckt W=0.11U L=0.059U
X_MXN48 NBL[1] VPW NET143 VPW dslnfetwl_ckt W=0.11U L=0.059U
X_MXN49 NBL[0] VPW NET111 VPW dslnfetwl_ckt W=0.11U L=0.059U
X_MXN50 VSSE NET84 NET103 VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MXN51 VSSE NET80 NET147 VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MXP12 NET95 NET96 VDDC VNWC dslpfetpu_ckt W=0.06U L=0.055U
X_MXP13 NET75 NET76 VDDC VNWC dslpfetpu_ckt W=0.06U L=0.055U
X_MXP14 NET99 NET100 VDDC VNWC dslpfetpu_ckt W=0.06U L=0.055U
X_MXP15 VDDC NET92 NET89 VNWC dslpfetpu_ckt W=0.06U L=0.055U
X_MXP16 VDDC NET88 NET85 VNWC dslpfetpu_ckt W=0.06U L=0.055U
X_MXP17 NET71 NET72 VDDC VNWC dslpfetpu_ckt W=0.06U L=0.055U
X_MXP18 NET83 NET84 VDDC VNWC dslpfetpu_ckt W=0.06U L=0.055U
X_MXP19 NET79 NET80 VDDC VNWC dslpfetpu_ckt W=0.06U L=0.055U
.ENDS sram464x144CCHD4_STRAP
****
.SUBCKT sram464x144CCHD4WD_EDG_STRP VNWC VNWP VPW VSSE
** sram464x144CCHD4WD_EDG_STRP: 2 flat devices **
X_MXN1 VSSE NET16 NET15 VPW dslnfetpd_ckt W=0.142U L=0.055U
X_MXN3 VSSE NET12 NET11 VPW dslnfetpd_ckt W=0.142U L=0.055U
.ENDS sram464x144CCHD4WD_EDG_STRP
****
.SUBCKT sram464x144MEM_L_STRAPROW BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4
+  BL[0]_5 BL[0]_6 BL[0]_7 BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13
+  BL[0]_14 BL[0]_15 BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21
+  BL[0]_22 BL[0]_23 BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29
+  BL[0]_30 BL[0]_31 BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1
+  BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10
+  BL[1]_11 BL[1]_12 BL[1]_13 BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18
+  BL[1]_19 BL[1]_20 BL[1]_21 BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26
+  BL[1]_27 BL[1]_28 BL[1]_29 BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34
+  BL[1]_35 BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7
+  BL[2]_8 BL[2]_9 BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15
+  BL[2]_16 BL[2]_17 BL[2]_18 BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23
+  BL[2]_24 BL[2]_25 BL[2]_26 BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31
+  BL[2]_32 BL[2]_33 BL[2]_34 BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4
+  BL[3]_5 BL[3]_6 BL[3]_7 BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13
+  BL[3]_14 BL[3]_15 BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21
+  BL[3]_22 BL[3]_23 BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29
+  BL[3]_30 BL[3]_31 BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1
+  NBL[0]_2 NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9
+  NBL[0]_10 NBL[0]_11 NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16
+  NBL[0]_17 NBL[0]_18 NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23
+  NBL[0]_24 NBL[0]_25 NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30
+  NBL[0]_31 NBL[0]_32 NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1
+  NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9
+  NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16
+  NBL[1]_17 NBL[1]_18 NBL[1]_19 NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23
+  NBL[1]_24 NBL[1]_25 NBL[1]_26 NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30
+  NBL[1]_31 NBL[1]_32 NBL[1]_33 NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1
+  NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9
+  NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13 NBL[2]_14 NBL[2]_15 NBL[2]_16
+  NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20 NBL[2]_21 NBL[2]_22 NBL[2]_23
+  NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27 NBL[2]_28 NBL[2]_29 NBL[2]_30
+  NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34 NBL[2]_35 NBL[3]_0 NBL[3]_1
+  NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 NBL[3]_8 NBL[3]_9
+  NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13 NBL[3]_14 NBL[3]_15 NBL[3]_16
+  NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20 NBL[3]_21 NBL[3]_22 NBL[3]_23
+  NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27 NBL[3]_28 NBL[3]_29 NBL[3]_30
+  NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34 NBL[3]_35 VDDC_0 VDDC_1 VDDC_2
+  VDDC_3 VDDC_4 VDDC_5 VDDC_6 VDDC_7 VDDC_8 VDDC_9 VDDC_10 VDDC_11 VDDC_12
+  VDDC_13 VDDC_14 VDDC_15 VDDC_16 VDDC_17 VDDC_18 VDDC_19 VDDC_20 VDDC_21
+  VDDC_22 VDDC_23 VDDC_24 VDDC_25 VDDC_26 VDDC_27 VDDC_28 VDDC_29 VDDC_30
+  VDDC_31 VDDC_32 VDDC_33 VDDC_34 VDDC_35 VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3
+  VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8 VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12
+  VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16 VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20
+  VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24 VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28
+  VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32 VDDPE_33 VDDPE_34 VDDPE_35 VNWC VNWP_0
+  VNWP_1 VPW
** sram464x144MEM_L_STRAPROW: 868 flat devices **
XMEM_STRAP0 BL[0]_0 BL[1]_0 BL[2]_0 BL[3]_0 NBL[0]_0 NBL[1]_0 NBL[2]_0
+  NBL[3]_0 VDDC_0 VNWC VDDPE_0 VNWC VPW VPW sram464x144CCHD4_STRAP
XMEM_STRAP1 BL[0]_1 BL[1]_1 BL[2]_1 BL[3]_1 NBL[0]_1 NBL[1]_1 NBL[2]_1
+  NBL[3]_1 VDDC_1 VNWC VDDPE_1 VNWC VPW VPW sram464x144CCHD4_STRAP
XMEM_STRAP10 BL[0]_10 BL[1]_10 BL[2]_10 BL[3]_10 NBL[0]_10 NBL[1]_10 NBL[2]_10
+  NBL[3]_10 VDDC_10 VNWC VDDPE_10 VNWC VPW VPW sram464x144CCHD4_STRAP
XMEM_STRAP11 BL[0]_11 BL[1]_11 BL[2]_11 BL[3]_11 NBL[0]_11 NBL[1]_11 NBL[2]_11
+  NBL[3]_11 VDDC_11 VNWC VDDPE_11 VNWC VPW VPW sram464x144CCHD4_STRAP
XMEM_STRAP12 BL[0]_12 BL[1]_12 BL[2]_12 BL[3]_12 NBL[0]_12 NBL[1]_12 NBL[2]_12
+  NBL[3]_12 VDDC_12 VNWC VDDPE_12 VNWC VPW VPW sram464x144CCHD4_STRAP
XMEM_STRAP13 BL[0]_13 BL[1]_13 BL[2]_13 BL[3]_13 NBL[0]_13 NBL[1]_13 NBL[2]_13
+  NBL[3]_13 VDDC_13 VNWC VDDPE_13 VNWC VPW VPW sram464x144CCHD4_STRAP
XMEM_STRAP14 BL[0]_14 BL[1]_14 BL[2]_14 BL[3]_14 NBL[0]_14 NBL[1]_14 NBL[2]_14
+  NBL[3]_14 VDDC_14 VNWC VDDPE_14 VNWC VPW VPW sram464x144CCHD4_STRAP
XMEM_STRAP15 BL[0]_15 BL[1]_15 BL[2]_15 BL[3]_15 NBL[0]_15 NBL[1]_15 NBL[2]_15
+  NBL[3]_15 VDDC_15 VNWC VDDPE_15 VNWC VPW VPW sram464x144CCHD4_STRAP
XMEM_STRAP16 BL[0]_16 BL[1]_16 BL[2]_16 BL[3]_16 NBL[0]_16 NBL[1]_16 NBL[2]_16
+  NBL[3]_16 VDDC_16 VNWC VDDPE_16 VNWC VPW VPW sram464x144CCHD4_STRAP
XMEM_STRAP17 BL[0]_17 BL[1]_17 BL[2]_17 BL[3]_17 NBL[0]_17 NBL[1]_17 NBL[2]_17
+  NBL[3]_17 VDDC_17 VNWC VDDPE_17 VNWC VPW VPW sram464x144CCHD4_STRAP
XMEM_STRAP18 BL[0]_18 BL[1]_18 BL[2]_18 BL[3]_18 NBL[0]_18 NBL[1]_18 NBL[2]_18
+  NBL[3]_18 VDDC_18 VNWC VDDPE_18 VNWC VPW VPW sram464x144CCHD4_STRAP
XMEM_STRAP19 BL[0]_19 BL[1]_19 BL[2]_19 BL[3]_19 NBL[0]_19 NBL[1]_19 NBL[2]_19
+  NBL[3]_19 VDDC_19 VNWC VDDPE_19 VNWC VPW VPW sram464x144CCHD4_STRAP
XMEM_STRAP2 BL[0]_2 BL[1]_2 BL[2]_2 BL[3]_2 NBL[0]_2 NBL[1]_2 NBL[2]_2
+  NBL[3]_2 VDDC_2 VNWC VDDPE_2 VNWC VPW VPW sram464x144CCHD4_STRAP
XMEM_STRAP20 BL[0]_20 BL[1]_20 BL[2]_20 BL[3]_20 NBL[0]_20 NBL[1]_20 NBL[2]_20
+  NBL[3]_20 VDDC_20 VNWC VDDPE_20 VNWC VPW VPW sram464x144CCHD4_STRAP
XMEM_STRAP21 BL[0]_21 BL[1]_21 BL[2]_21 BL[3]_21 NBL[0]_21 NBL[1]_21 NBL[2]_21
+  NBL[3]_21 VDDC_21 VNWC VDDPE_21 VNWC VPW VPW sram464x144CCHD4_STRAP
XMEM_STRAP22 BL[0]_22 BL[1]_22 BL[2]_22 BL[3]_22 NBL[0]_22 NBL[1]_22 NBL[2]_22
+  NBL[3]_22 VDDC_22 VNWC VDDPE_22 VNWC VPW VPW sram464x144CCHD4_STRAP
XMEM_STRAP23 BL[0]_23 BL[1]_23 BL[2]_23 BL[3]_23 NBL[0]_23 NBL[1]_23 NBL[2]_23
+  NBL[3]_23 VDDC_23 VNWC VDDPE_23 VNWC VPW VPW sram464x144CCHD4_STRAP
XMEM_STRAP24 BL[0]_24 BL[1]_24 BL[2]_24 BL[3]_24 NBL[0]_24 NBL[1]_24 NBL[2]_24
+  NBL[3]_24 VDDC_24 VNWC VDDPE_24 VNWC VPW VPW sram464x144CCHD4_STRAP
XMEM_STRAP25 BL[0]_25 BL[1]_25 BL[2]_25 BL[3]_25 NBL[0]_25 NBL[1]_25 NBL[2]_25
+  NBL[3]_25 VDDC_25 VNWC VDDPE_25 VNWC VPW VPW sram464x144CCHD4_STRAP
XMEM_STRAP26 BL[0]_26 BL[1]_26 BL[2]_26 BL[3]_26 NBL[0]_26 NBL[1]_26 NBL[2]_26
+  NBL[3]_26 VDDC_26 VNWC VDDPE_26 VNWC VPW VPW sram464x144CCHD4_STRAP
XMEM_STRAP27 BL[0]_27 BL[1]_27 BL[2]_27 BL[3]_27 NBL[0]_27 NBL[1]_27 NBL[2]_27
+  NBL[3]_27 VDDC_27 VNWC VDDPE_27 VNWC VPW VPW sram464x144CCHD4_STRAP
XMEM_STRAP28 BL[0]_28 BL[1]_28 BL[2]_28 BL[3]_28 NBL[0]_28 NBL[1]_28 NBL[2]_28
+  NBL[3]_28 VDDC_28 VNWC VDDPE_28 VNWC VPW VPW sram464x144CCHD4_STRAP
XMEM_STRAP29 BL[0]_29 BL[1]_29 BL[2]_29 BL[3]_29 NBL[0]_29 NBL[1]_29 NBL[2]_29
+  NBL[3]_29 VDDC_29 VNWC VDDPE_29 VNWC VPW VPW sram464x144CCHD4_STRAP
XMEM_STRAP3 BL[0]_3 BL[1]_3 BL[2]_3 BL[3]_3 NBL[0]_3 NBL[1]_3 NBL[2]_3
+  NBL[3]_3 VDDC_3 VNWC VDDPE_3 VNWC VPW VPW sram464x144CCHD4_STRAP
XMEM_STRAP30 BL[0]_30 BL[1]_30 BL[2]_30 BL[3]_30 NBL[0]_30 NBL[1]_30 NBL[2]_30
+  NBL[3]_30 VDDC_30 VNWC VDDPE_30 VNWC VPW VPW sram464x144CCHD4_STRAP
XMEM_STRAP31 BL[0]_31 BL[1]_31 BL[2]_31 BL[3]_31 NBL[0]_31 NBL[1]_31 NBL[2]_31
+  NBL[3]_31 VDDC_31 VNWC VDDPE_31 VNWC VPW VPW sram464x144CCHD4_STRAP
XMEM_STRAP32 BL[0]_32 BL[1]_32 BL[2]_32 BL[3]_32 NBL[0]_32 NBL[1]_32 NBL[2]_32
+  NBL[3]_32 VDDC_32 VNWC VDDPE_32 VNWC VPW VPW sram464x144CCHD4_STRAP
XMEM_STRAP33 BL[0]_33 BL[1]_33 BL[2]_33 BL[3]_33 NBL[0]_33 NBL[1]_33 NBL[2]_33
+  NBL[3]_33 VDDC_33 VNWC VDDPE_33 VNWC VPW VPW sram464x144CCHD4_STRAP
XMEM_STRAP34 BL[0]_34 BL[1]_34 BL[2]_34 BL[3]_34 NBL[0]_34 NBL[1]_34 NBL[2]_34
+  NBL[3]_34 VDDC_34 VNWC VDDPE_34 VNWC VPW VPW sram464x144CCHD4_STRAP
XMEM_STRAP35 BL[0]_35 BL[1]_35 BL[2]_35 BL[3]_35 NBL[0]_35 NBL[1]_35 NBL[2]_35
+  NBL[3]_35 VDDC_35 VNWC VDDPE_35 VNWC VPW VPW sram464x144CCHD4_STRAP
XMEM_STRAP4 BL[0]_4 BL[1]_4 BL[2]_4 BL[3]_4 NBL[0]_4 NBL[1]_4 NBL[2]_4
+  NBL[3]_4 VDDC_4 VNWC VDDPE_4 VNWC VPW VPW sram464x144CCHD4_STRAP
XMEM_STRAP5 BL[0]_5 BL[1]_5 BL[2]_5 BL[3]_5 NBL[0]_5 NBL[1]_5 NBL[2]_5
+  NBL[3]_5 VDDC_5 VNWC VDDPE_5 VNWC VPW VPW sram464x144CCHD4_STRAP
XMEM_STRAP6 BL[0]_6 BL[1]_6 BL[2]_6 BL[3]_6 NBL[0]_6 NBL[1]_6 NBL[2]_6
+  NBL[3]_6 VDDC_6 VNWC VDDPE_6 VNWC VPW VPW sram464x144CCHD4_STRAP
XMEM_STRAP7 BL[0]_7 BL[1]_7 BL[2]_7 BL[3]_7 NBL[0]_7 NBL[1]_7 NBL[2]_7
+  NBL[3]_7 VDDC_7 VNWC VDDPE_7 VNWC VPW VPW sram464x144CCHD4_STRAP
XMEM_STRAP8 BL[0]_8 BL[1]_8 BL[2]_8 BL[3]_8 NBL[0]_8 NBL[1]_8 NBL[2]_8
+  NBL[3]_8 VDDC_8 VNWC VDDPE_8 VNWC VPW VPW sram464x144CCHD4_STRAP
XMEM_STRAP9 BL[0]_9 BL[1]_9 BL[2]_9 BL[3]_9 NBL[0]_9 NBL[1]_9 NBL[2]_9
+  NBL[3]_9 VDDC_9 VNWC VDDPE_9 VNWC VPW VPW sram464x144CCHD4_STRAP
XMEM_STRAPEDGEL VNWC VNWP_0 VPW VPW sram464x144CCHD4_EDG_STRAP
XMEM_STRAPEDGER VNWC VNWP_1 VPW VPW sram464x144CCHD4WD_EDG_STRP
.ENDS sram464x144MEM_L_STRAPROW
****
.SUBCKT sram464x144MEM_L_BOT_ROW BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4
+  BL[0]_5 BL[0]_6 BL[0]_7 BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13
+  BL[0]_14 BL[0]_15 BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21
+  BL[0]_22 BL[0]_23 BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29
+  BL[0]_30 BL[0]_31 BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1
+  BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10
+  BL[1]_11 BL[1]_12 BL[1]_13 BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18
+  BL[1]_19 BL[1]_20 BL[1]_21 BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26
+  BL[1]_27 BL[1]_28 BL[1]_29 BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34
+  BL[1]_35 BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7
+  BL[2]_8 BL[2]_9 BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15
+  BL[2]_16 BL[2]_17 BL[2]_18 BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23
+  BL[2]_24 BL[2]_25 BL[2]_26 BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31
+  BL[2]_32 BL[2]_33 BL[2]_34 BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4
+  BL[3]_5 BL[3]_6 BL[3]_7 BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13
+  BL[3]_14 BL[3]_15 BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21
+  BL[3]_22 BL[3]_23 BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29
+  BL[3]_30 BL[3]_31 BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1
+  NBL[0]_2 NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9
+  NBL[0]_10 NBL[0]_11 NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16
+  NBL[0]_17 NBL[0]_18 NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23
+  NBL[0]_24 NBL[0]_25 NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30
+  NBL[0]_31 NBL[0]_32 NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1
+  NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9
+  NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16
+  NBL[1]_17 NBL[1]_18 NBL[1]_19 NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23
+  NBL[1]_24 NBL[1]_25 NBL[1]_26 NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30
+  NBL[1]_31 NBL[1]_32 NBL[1]_33 NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1
+  NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9
+  NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13 NBL[2]_14 NBL[2]_15 NBL[2]_16
+  NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20 NBL[2]_21 NBL[2]_22 NBL[2]_23
+  NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27 NBL[2]_28 NBL[2]_29 NBL[2]_30
+  NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34 NBL[2]_35 NBL[3]_0 NBL[3]_1
+  NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 NBL[3]_8 NBL[3]_9
+  NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13 NBL[3]_14 NBL[3]_15 NBL[3]_16
+  NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20 NBL[3]_21 NBL[3]_22 NBL[3]_23
+  NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27 NBL[3]_28 NBL[3]_29 NBL[3]_30
+  NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34 NBL[3]_35 VDDCE_0 VDDCE_1 VDDCE_2
+  VDDCE_3 VDDCE_4 VDDCE_5 VDDCE_6 VDDCE_7 VDDCE_8 VDDCE_9 VDDCE_10 VDDCE_11
+  VDDCE_12 VDDCE_13 VDDCE_14 VDDCE_15 VDDCE_16 VDDCE_17 VDDCE_18 VDDCE_19
+  VDDCE_20 VDDCE_21 VDDCE_22 VDDCE_23 VDDCE_24 VDDCE_25 VDDCE_26 VDDCE_27
+  VDDCE_28 VDDCE_29 VDDCE_30 VDDCE_31 VDDCE_32 VDDCE_33 VDDCE_34 VDDCE_35
+  VDDC_0 VDDC_1 VDDC_2 VDDC_3 VDDC_4 VDDC_5 VDDC_6 VDDC_7 VDDC_8 VDDC_9
+  VDDC_10 VDDC_11 VDDC_12 VDDC_13 VDDC_14 VDDC_15 VDDC_16 VDDC_17 VDDC_18
+  VDDC_19 VDDC_20 VDDC_21 VDDC_22 VDDC_23 VDDC_24 VDDC_25 VDDC_26 VDDC_27
+  VDDC_28 VDDC_29 VDDC_30 VDDC_31 VDDC_32 VDDC_33 VDDC_34 VDDC_35 VDDPE_0
+  VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8 VDDPE_9
+  VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16 VDDPE_17
+  VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24 VDDPE_25
+  VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32 VDDPE_33
+  VDDPE_34 VDDPE_35 VNWC_0 VNWC_1 VNWC_2 VNWC_3 VNWC_4 VNWC_5 VNWC_6 VNWC_7
+  VNWC_8 VNWC_9 VNWC_10 VNWC_11 VNWC_12 VNWC_13 VNWC_14 VNWC_15 VNWC_16
+  VNWC_17 VNWC_18 VNWC_19 VNWC_20 VNWC_21 VNWC_22 VNWC_23 VNWC_24 VNWC_25
+  VNWC_26 VNWC_27 VNWC_28 VNWC_29 VNWC_30 VNWC_31 VNWC_32 VNWC_33 VNWC_34
+  VNWC_35 VNWC_36 VNWC_37 VNWP_0 VNWP_1 VPW_0 VPW_1 VPW_2 VPW_3 VPW_4 VPW_5
+  VPW_6 VPW_7 VPW_8 VPW_9 VPW_10 VPW_11 VPW_12 VPW_13 VPW_14 VPW_15 VPW_16
+  VPW_17 VPW_18 VPW_19 VPW_20 VPW_21 VPW_22 VPW_23 VPW_24 VPW_25 VPW_26
+  VPW_27 VPW_28 VPW_29 VPW_30 VPW_31 VPW_32 VPW_33 VPW_34 VPW_35 VSSE WL[0]
+  WL[1]
** sram464x144MEM_L_BOT_ROW: 1732 flat devices **
XMEM_L_COL_1 BL[0]_1 BL[1]_1 BL[2]_1 BL[3]_1 CORED00_304 CORED01_306
+  CORED10_308 CORED11_310 CORED20_312 CORED21_314 CORED30_316 CORED31_318
+  NBL[0]_1 NBL[1]_1 NBL[2]_1 NBL[3]_1 NCORED00_320 NCORED01_322 NCORED10_324
+  NCORED11_326 NCORED20_328 NCORED21_330 NCORED30_332 NCORED31_334 VDDC_1
+  VDDCE_1 VDDPE_1 VNWC_2 VPW_1 VSSE WL[0] WL[1] sram464x144CCHD4
XMEM_L_COL_10 BL[0]_10 BL[1]_10 BL[2]_10 BL[3]_10 CORED00_592 CORED01_594
+  CORED10_596 CORED11_598 CORED20_600 CORED21_602 CORED30_604 CORED31_606
+  NBL[0]_10 NBL[1]_10 NBL[2]_10 NBL[3]_10 NCORED00_608 NCORED01_610
+  NCORED10_612 NCORED11_614 NCORED20_616 NCORED21_618 NCORED30_620
+  NCORED31_622 VDDC_10 VDDCE_10 VDDPE_10 VNWC_11 VPW_10 VSSE WL[0] WL[1]
+  sram464x144CCHD4
XMEM_L_COL_11 BL[0]_11 BL[1]_11 BL[2]_11 BL[3]_11 CORED00_624 CORED01_626
+  CORED10_628 CORED11_630 CORED20_632 CORED21_634 CORED30_636 CORED31_638
+  NBL[0]_11 NBL[1]_11 NBL[2]_11 NBL[3]_11 NCORED00_640 NCORED01_642
+  NCORED10_644 NCORED11_646 NCORED20_648 NCORED21_650 NCORED30_652
+  NCORED31_654 VDDC_11 VDDCE_11 VDDPE_11 VNWC_12 VPW_11 VSSE WL[0] WL[1]
+  sram464x144CCHD4
XMEM_L_COL_12 BL[0]_12 BL[1]_12 BL[2]_12 BL[3]_12 CORED00_688 CORED01_690
+  CORED10_692 CORED11_694 CORED20_696 CORED21_698 CORED30_700 CORED31_702
+  NBL[0]_12 NBL[1]_12 NBL[2]_12 NBL[3]_12 NCORED00_704 NCORED01_706
+  NCORED10_708 NCORED11_710 NCORED20_712 NCORED21_714 NCORED30_716
+  NCORED31_718 VDDC_12 VDDCE_12 VDDPE_12 VNWC_13 VPW_12 VSSE WL[0] WL[1]
+  sram464x144CCHD4
XMEM_L_COL_13 BL[0]_13 BL[1]_13 BL[2]_13 BL[3]_13 CORED00_752 CORED01_754
+  CORED10_756 CORED11_758 CORED20_760 CORED21_762 CORED30_764 CORED31_766
+  NBL[0]_13 NBL[1]_13 NBL[2]_13 NBL[3]_13 NCORED00_768 NCORED01_770
+  NCORED10_772 NCORED11_774 NCORED20_776 NCORED21_778 NCORED30_780
+  NCORED31_782 VDDC_13 VDDCE_13 VDDPE_13 VNWC_14 VPW_13 VSSE WL[0] WL[1]
+  sram464x144CCHD4
XMEM_L_COL_14 BL[0]_14 BL[1]_14 BL[2]_14 BL[3]_14 CORED00_816 CORED01_818
+  CORED10_820 CORED11_822 CORED20_824 CORED21_826 CORED30_828 CORED31_830
+  NBL[0]_14 NBL[1]_14 NBL[2]_14 NBL[3]_14 NCORED00_832 NCORED01_834
+  NCORED10_836 NCORED11_838 NCORED20_840 NCORED21_842 NCORED30_844
+  NCORED31_846 VDDC_14 VDDCE_14 VDDPE_14 VNWC_15 VPW_14 VSSE WL[0] WL[1]
+  sram464x144CCHD4
XMEM_L_COL_15 BL[0]_15 BL[1]_15 BL[2]_15 BL[3]_15 CORED00_880 CORED01_882
+  CORED10_884 CORED11_886 CORED20_888 CORED21_890 CORED30_892 CORED31_894
+  NBL[0]_15 NBL[1]_15 NBL[2]_15 NBL[3]_15 NCORED00_896 NCORED01_898
+  NCORED10_900 NCORED11_902 NCORED20_904 NCORED21_906 NCORED30_908
+  NCORED31_910 VDDC_15 VDDCE_15 VDDPE_15 VNWC_16 VPW_15 VSSE WL[0] WL[1]
+  sram464x144CCHD4
XMEM_L_COL_16 BL[0]_16 BL[1]_16 BL[2]_16 BL[3]_16 CORED00_944 CORED01_946
+  CORED10_948 CORED11_950 CORED20_952 CORED21_954 CORED30_956 CORED31_958
+  NBL[0]_16 NBL[1]_16 NBL[2]_16 NBL[3]_16 NCORED00_960 NCORED01_962
+  NCORED10_964 NCORED11_966 NCORED20_968 NCORED21_970 NCORED30_972
+  NCORED31_974 VDDC_16 VDDCE_16 VDDPE_16 VNWC_17 VPW_16 VSSE WL[0] WL[1]
+  sram464x144CCHD4
XMEM_L_COL_17 BL[0]_17 BL[1]_17 BL[2]_17 BL[3]_17 CORED00_976 CORED01_978
+  CORED10_980 CORED11_982 CORED20_984 CORED21_986 CORED30_988 CORED31_990
+  NBL[0]_17 NBL[1]_17 NBL[2]_17 NBL[3]_17 NCORED00_992 NCORED01_994
+  NCORED10_996 NCORED11_998 NCORED20_1000 NCORED21_1002 NCORED30_1004
+  NCORED31_1006 VDDC_17 VDDCE_17 VDDPE_17 VNWC_18 VPW_17 VSSE WL[0] WL[1]
+  sram464x144CCHD4
XMEM_L_COL_18 BL[0]_18 BL[1]_18 BL[2]_18 BL[3]_18 CORED00_1008 CORED01_1010
+  CORED10_1012 CORED11_1014 CORED20_1016 CORED21_1018 CORED30_1020
+  CORED31_1022 NBL[0]_18 NBL[1]_18 NBL[2]_18 NBL[3]_18 NCORED00_1024
+  NCORED01_1026 NCORED10_1028 NCORED11_1030 NCORED20_1032 NCORED21_1034
+  NCORED30_1036 NCORED31_1038 VDDC_18 VDDCE_18 VDDPE_18 VNWC_19 VPW_18 VSSE
+  WL[0] WL[1] sram464x144CCHD4
XMEM_L_COL_19 BL[0]_19 BL[1]_19 BL[2]_19 BL[3]_19 CORED00_1040 CORED01_1042
+  CORED10_1044 CORED11_1046 CORED20_1048 CORED21_1050 CORED30_1052
+  CORED31_1054 NBL[0]_19 NBL[1]_19 NBL[2]_19 NBL[3]_19 NCORED00_1056
+  NCORED01_1058 NCORED10_1060 NCORED11_1062 NCORED20_1064 NCORED21_1066
+  NCORED30_1068 NCORED31_1070 VDDC_19 VDDCE_19 VDDPE_19 VNWC_20 VPW_19 VSSE
+  WL[0] WL[1] sram464x144CCHD4
XMEM_L_COL_2 BL[0]_2 BL[1]_2 BL[2]_2 BL[3]_2 CORED00_336 CORED01_338
+  CORED10_340 CORED11_342 CORED20_344 CORED21_346 CORED30_348 CORED31_350
+  NBL[0]_2 NBL[1]_2 NBL[2]_2 NBL[3]_2 NCORED00_352 NCORED01_354 NCORED10_356
+  NCORED11_358 NCORED20_360 NCORED21_362 NCORED30_364 NCORED31_366 VDDC_2
+  VDDCE_2 VDDPE_2 VNWC_3 VPW_2 VSSE WL[0] WL[1] sram464x144CCHD4
XMEM_L_COL_20 BL[0]_20 BL[1]_20 BL[2]_20 BL[3]_20 CORED00 CORED01 CORED10
+  CORED11 CORED20 CORED21 CORED30 CORED31 NBL[0]_20 NBL[1]_20 NBL[2]_20
+  NBL[3]_20 NCORED00 NCORED01 NCORED10 NCORED11 NCORED20 NCORED21 NCORED30
+  NCORED31 VDDC_20 VDDCE_20 VDDPE_20 VNWC_21 VPW_20 VSSE WL[0] WL[1]
+  sram464x144CCHD4
XMEM_L_COL_21 BL[0]_21 BL[1]_21 BL[2]_21 BL[3]_21 CORED00_16 CORED01_18
+  CORED10_20 CORED11_22 CORED20_24 CORED21_26 CORED30_28 CORED31_30 NBL[0]_21
+  NBL[1]_21 NBL[2]_21 NBL[3]_21 NCORED00_32 NCORED01_34 NCORED10_36
+  NCORED11_38 NCORED20_40 NCORED21_42 NCORED30_44 NCORED31_46 VDDC_21
+  VDDCE_21 VDDPE_21 VNWC_22 VPW_21 VSSE WL[0] WL[1] sram464x144CCHD4
XMEM_L_COL_22 BL[0]_22 BL[1]_22 BL[2]_22 BL[3]_22 CORED00_48 CORED01_50
+  CORED10_52 CORED11_54 CORED20_56 CORED21_58 CORED30_60 CORED31_62 NBL[0]_22
+  NBL[1]_22 NBL[2]_22 NBL[3]_22 NCORED00_64 NCORED01_66 NCORED10_68
+  NCORED11_70 NCORED20_72 NCORED21_74 NCORED30_76 NCORED31_78 VDDC_22
+  VDDCE_22 VDDPE_22 VNWC_23 VPW_22 VSSE WL[0] WL[1] sram464x144CCHD4
XMEM_L_COL_23 BL[0]_23 BL[1]_23 BL[2]_23 BL[3]_23 CORED00_80 CORED01_82
+  CORED10_84 CORED11_86 CORED20_88 CORED21_90 CORED30_92 CORED31_94 NBL[0]_23
+  NBL[1]_23 NBL[2]_23 NBL[3]_23 NCORED00_96 NCORED01_98 NCORED10_100
+  NCORED11_102 NCORED20_104 NCORED21_106 NCORED30_108 NCORED31_110 VDDC_23
+  VDDCE_23 VDDPE_23 VNWC_24 VPW_23 VSSE WL[0] WL[1] sram464x144CCHD4
XMEM_L_COL_24 BL[0]_24 BL[1]_24 BL[2]_24 BL[3]_24 CORED00_112 CORED01_114
+  CORED10_116 CORED11_118 CORED20_120 CORED21_122 CORED30_124 CORED31_126
+  NBL[0]_24 NBL[1]_24 NBL[2]_24 NBL[3]_24 NCORED00_128 NCORED01_130
+  NCORED10_132 NCORED11_134 NCORED20_136 NCORED21_138 NCORED30_140
+  NCORED31_142 VDDC_24 VDDCE_24 VDDPE_24 VNWC_25 VPW_24 VSSE WL[0] WL[1]
+  sram464x144CCHD4
XMEM_L_COL_25 BL[0]_25 BL[1]_25 BL[2]_25 BL[3]_25 CORED00_144 CORED01_146
+  CORED10_148 CORED11_150 CORED20_152 CORED21_154 CORED30_156 CORED31_158
+  NBL[0]_25 NBL[1]_25 NBL[2]_25 NBL[3]_25 NCORED00_160 NCORED01_162
+  NCORED10_164 NCORED11_166 NCORED20_168 NCORED21_170 NCORED30_172
+  NCORED31_174 VDDC_25 VDDCE_25 VDDPE_25 VNWC_26 VPW_25 VSSE WL[0] WL[1]
+  sram464x144CCHD4
XMEM_L_COL_26 BL[0]_26 BL[1]_26 BL[2]_26 BL[3]_26 CORED00_176 CORED01_178
+  CORED10_180 CORED11_182 CORED20_184 CORED21_186 CORED30_188 CORED31_190
+  NBL[0]_26 NBL[1]_26 NBL[2]_26 NBL[3]_26 NCORED00_192 NCORED01_194
+  NCORED10_196 NCORED11_198 NCORED20_200 NCORED21_202 NCORED30_204
+  NCORED31_206 VDDC_26 VDDCE_26 VDDPE_26 VNWC_27 VPW_26 VSSE WL[0] WL[1]
+  sram464x144CCHD4
XMEM_L_COL_27 BL[0]_27 BL[1]_27 BL[2]_27 BL[3]_27 CORED00_208 CORED01_210
+  CORED10_212 CORED11_214 CORED20_216 CORED21_218 CORED30_220 CORED31_222
+  NBL[0]_27 NBL[1]_27 NBL[2]_27 NBL[3]_27 NCORED00_224 NCORED01_226
+  NCORED10_228 NCORED11_230 NCORED20_232 NCORED21_234 NCORED30_236
+  NCORED31_238 VDDC_27 VDDCE_27 VDDPE_27 VNWC_28 VPW_27 VSSE WL[0] WL[1]
+  sram464x144CCHD4
XMEM_L_COL_28 BL[0]_28 BL[1]_28 BL[2]_28 BL[3]_28 CORED00_240 CORED01_242
+  CORED10_244 CORED11_246 CORED20_248 CORED21_250 CORED30_252 CORED31_254
+  NBL[0]_28 NBL[1]_28 NBL[2]_28 NBL[3]_28 NCORED00_256 NCORED01_258
+  NCORED10_260 NCORED11_262 NCORED20_264 NCORED21_266 NCORED30_268
+  NCORED31_270 VDDC_28 VDDCE_28 VDDPE_28 VNWC_29 VPW_28 VSSE WL[0] WL[1]
+  sram464x144CCHD4
XMEM_L_COL_29 BL[0]_29 BL[1]_29 BL[2]_29 BL[3]_29 CORED00_272 CORED01_274
+  CORED10_276 CORED11_278 CORED20_280 CORED21_282 CORED30_284 CORED31_286
+  NBL[0]_29 NBL[1]_29 NBL[2]_29 NBL[3]_29 NCORED00_288 NCORED01_290
+  NCORED10_292 NCORED11_294 NCORED20_296 NCORED21_298 NCORED30_300
+  NCORED31_302 VDDC_29 VDDCE_29 VDDPE_29 VNWC_30 VPW_29 VSSE WL[0] WL[1]
+  sram464x144CCHD4
XMEM_L_COL_3 BL[0]_3 BL[1]_3 BL[2]_3 BL[3]_3 CORED00_368 CORED01_370
+  CORED10_372 CORED11_374 CORED20_376 CORED21_378 CORED30_380 CORED31_382
+  NBL[0]_3 NBL[1]_3 NBL[2]_3 NBL[3]_3 NCORED00_384 NCORED01_386 NCORED10_388
+  NCORED11_390 NCORED20_392 NCORED21_394 NCORED30_396 NCORED31_398 VDDC_3
+  VDDCE_3 VDDPE_3 VNWC_4 VPW_3 VSSE WL[0] WL[1] sram464x144CCHD4
XMEM_L_COL_30 BL[0]_30 BL[1]_30 BL[2]_30 BL[3]_30 CORED00_656 CORED01_658
+  CORED10_660 CORED11_662 CORED20_664 CORED21_666 CORED30_668 CORED31_670
+  NBL[0]_30 NBL[1]_30 NBL[2]_30 NBL[3]_30 NCORED00_672 NCORED01_674
+  NCORED10_676 NCORED11_678 NCORED20_680 NCORED21_682 NCORED30_684
+  NCORED31_686 VDDC_30 VDDCE_30 VDDPE_30 VNWC_31 VPW_30 VSSE WL[0] WL[1]
+  sram464x144CCHD4
XMEM_L_COL_31 BL[0]_31 BL[1]_31 BL[2]_31 BL[3]_31 CORED00_720 CORED01_722
+  CORED10_724 CORED11_726 CORED20_728 CORED21_730 CORED30_732 CORED31_734
+  NBL[0]_31 NBL[1]_31 NBL[2]_31 NBL[3]_31 NCORED00_736 NCORED01_738
+  NCORED10_740 NCORED11_742 NCORED20_744 NCORED21_746 NCORED30_748
+  NCORED31_750 VDDC_31 VDDCE_31 VDDPE_31 VNWC_32 VPW_31 VSSE WL[0] WL[1]
+  sram464x144CCHD4
XMEM_L_COL_32 BL[0]_32 BL[1]_32 BL[2]_32 BL[3]_32 CORED00_784 CORED01_786
+  CORED10_788 CORED11_790 CORED20_792 CORED21_794 CORED30_796 CORED31_798
+  NBL[0]_32 NBL[1]_32 NBL[2]_32 NBL[3]_32 NCORED00_800 NCORED01_802
+  NCORED10_804 NCORED11_806 NCORED20_808 NCORED21_810 NCORED30_812
+  NCORED31_814 VDDC_32 VDDCE_32 VDDPE_32 VNWC_33 VPW_32 VSSE WL[0] WL[1]
+  sram464x144CCHD4
XMEM_L_COL_33 BL[0]_33 BL[1]_33 BL[2]_33 BL[3]_33 CORED00_848 CORED01_850
+  CORED10_852 CORED11_854 CORED20_856 CORED21_858 CORED30_860 CORED31_862
+  NBL[0]_33 NBL[1]_33 NBL[2]_33 NBL[3]_33 NCORED00_864 NCORED01_866
+  NCORED10_868 NCORED11_870 NCORED20_872 NCORED21_874 NCORED30_876
+  NCORED31_878 VDDC_33 VDDCE_33 VDDPE_33 VNWC_34 VPW_33 VSSE WL[0] WL[1]
+  sram464x144CCHD4
XMEM_L_COL_34 BL[0]_34 BL[1]_34 BL[2]_34 BL[3]_34 CORED00_912 CORED01_914
+  CORED10_916 CORED11_918 CORED20_920 CORED21_922 CORED30_924 CORED31_926
+  NBL[0]_34 NBL[1]_34 NBL[2]_34 NBL[3]_34 NCORED00_928 NCORED01_930
+  NCORED10_932 NCORED11_934 NCORED20_936 NCORED21_938 NCORED30_940
+  NCORED31_942 VDDC_34 VDDCE_34 VDDPE_34 VNWC_35 VPW_34 VSSE WL[0] WL[1]
+  sram464x144CCHD4
XMEM_L_COL_4 BL[0]_4 BL[1]_4 BL[2]_4 BL[3]_4 CORED00_400 CORED01_402
+  CORED10_404 CORED11_406 CORED20_408 CORED21_410 CORED30_412 CORED31_414
+  NBL[0]_4 NBL[1]_4 NBL[2]_4 NBL[3]_4 NCORED00_416 NCORED01_418 NCORED10_420
+  NCORED11_422 NCORED20_424 NCORED21_426 NCORED30_428 NCORED31_430 VDDC_4
+  VDDCE_4 VDDPE_4 VNWC_5 VPW_4 VSSE WL[0] WL[1] sram464x144CCHD4
XMEM_L_COL_5 BL[0]_5 BL[1]_5 BL[2]_5 BL[3]_5 CORED00_432 CORED01_434
+  CORED10_436 CORED11_438 CORED20_440 CORED21_442 CORED30_444 CORED31_446
+  NBL[0]_5 NBL[1]_5 NBL[2]_5 NBL[3]_5 NCORED00_448 NCORED01_450 NCORED10_452
+  NCORED11_454 NCORED20_456 NCORED21_458 NCORED30_460 NCORED31_462 VDDC_5
+  VDDCE_5 VDDPE_5 VNWC_6 VPW_5 VSSE WL[0] WL[1] sram464x144CCHD4
XMEM_L_COL_6 BL[0]_6 BL[1]_6 BL[2]_6 BL[3]_6 CORED00_464 CORED01_466
+  CORED10_468 CORED11_470 CORED20_472 CORED21_474 CORED30_476 CORED31_478
+  NBL[0]_6 NBL[1]_6 NBL[2]_6 NBL[3]_6 NCORED00_480 NCORED01_482 NCORED10_484
+  NCORED11_486 NCORED20_488 NCORED21_490 NCORED30_492 NCORED31_494 VDDC_6
+  VDDCE_6 VDDPE_6 VNWC_7 VPW_6 VSSE WL[0] WL[1] sram464x144CCHD4
XMEM_L_COL_7 BL[0]_7 BL[1]_7 BL[2]_7 BL[3]_7 CORED00_496 CORED01_498
+  CORED10_500 CORED11_502 CORED20_504 CORED21_506 CORED30_508 CORED31_510
+  NBL[0]_7 NBL[1]_7 NBL[2]_7 NBL[3]_7 NCORED00_512 NCORED01_514 NCORED10_516
+  NCORED11_518 NCORED20_520 NCORED21_522 NCORED30_524 NCORED31_526 VDDC_7
+  VDDCE_7 VDDPE_7 VNWC_8 VPW_7 VSSE WL[0] WL[1] sram464x144CCHD4
XMEM_L_COL_8 BL[0]_8 BL[1]_8 BL[2]_8 BL[3]_8 CORED00_528 CORED01_530
+  CORED10_532 CORED11_534 CORED20_536 CORED21_538 CORED30_540 CORED31_542
+  NBL[0]_8 NBL[1]_8 NBL[2]_8 NBL[3]_8 NCORED00_544 NCORED01_546 NCORED10_548
+  NCORED11_550 NCORED20_552 NCORED21_554 NCORED30_556 NCORED31_558 VDDC_8
+  VDDCE_8 VDDPE_8 VNWC_9 VPW_8 VSSE WL[0] WL[1] sram464x144CCHD4
XMEM_L_COL_9 BL[0]_9 BL[1]_9 BL[2]_9 BL[3]_9 CORED00_560 CORED01_562
+  CORED10_564 CORED11_566 CORED20_568 CORED21_570 CORED30_572 CORED31_574
+  NBL[0]_9 NBL[1]_9 NBL[2]_9 NBL[3]_9 NCORED00_576 NCORED01_578 NCORED10_580
+  NCORED11_582 NCORED20_584 NCORED21_586 NCORED30_588 NCORED31_590 VDDC_9
+  VDDCE_9 VDDPE_9 VNWC_10 VPW_9 VSSE WL[0] WL[1] sram464x144CCHD4
XMEM_L_COL_BOT_L BL[0]_0 BL[1]_0 BL[2]_0 BL[3]_0 CORED00_1072 CORED01_1074
+  CORED10_1076 CORED11_1078 CORED20_1080 CORED21_1082 CORED30_1084
+  CORED31_1086 NBL[0]_0 NBL[1]_0 NBL[2]_0 NBL[3]_0 NCORED00_1088
+  NCORED01_1090 NCORED10_1092 NCORED11_1094 NCORED20_1096 NCORED21_1098
+  NCORED30_1100 NCORED31_1102 VDDC_0 VDDCE_0 VDDPE_0 VNWC_1 VPW_0 VSSE WL[0]
+  WL[1] sram464x144CCHD4
XMEM_L_COL_BOT_R BL[0]_35 BL[1]_35 BL[2]_35 BL[3]_35 CORED00_1104 CORED01_1106
+  CORED10_1108 CORED11_1110 CORED20_1112 CORED21_1114 CORED30_1116
+  CORED31_1118 NBL[0]_35 NBL[1]_35 NBL[2]_35 NBL[3]_35 NCORED00_1120
+  NCORED01_1122 NCORED10_1124 NCORED11_1126 NCORED20_1128 NCORED21_1130
+  NCORED30_1132 NCORED31_1134 VDDC_35 VDDCE_35 VDDPE_35 VNWC_36 VPW_35 VSSE
+  WL[0] WL[1] sram464x144CCHD4
XMEM_L_COL_EDGEL VNWC_0 VNWP_0 VSSE VSSE WL[0] WL[1] sram464x144CCHD4_EDG
XMEM_L_COL_EDGER VNWC_37 VNWP_1 VSSE VSSE WL[0] WL[1] sram464x144CCHD4WD_EDG
.ENDS sram464x144MEM_L_BOT_ROW
****
.SUBCKT sram464x144MEM_L_TOP_ROW BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4
+  BL[0]_5 BL[0]_6 BL[0]_7 BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13
+  BL[0]_14 BL[0]_15 BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21
+  BL[0]_22 BL[0]_23 BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29
+  BL[0]_30 BL[0]_31 BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1
+  BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10
+  BL[1]_11 BL[1]_12 BL[1]_13 BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18
+  BL[1]_19 BL[1]_20 BL[1]_21 BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26
+  BL[1]_27 BL[1]_28 BL[1]_29 BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34
+  BL[1]_35 BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7
+  BL[2]_8 BL[2]_9 BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15
+  BL[2]_16 BL[2]_17 BL[2]_18 BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23
+  BL[2]_24 BL[2]_25 BL[2]_26 BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31
+  BL[2]_32 BL[2]_33 BL[2]_34 BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4
+  BL[3]_5 BL[3]_6 BL[3]_7 BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13
+  BL[3]_14 BL[3]_15 BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21
+  BL[3]_22 BL[3]_23 BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29
+  BL[3]_30 BL[3]_31 BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1
+  NBL[0]_2 NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9
+  NBL[0]_10 NBL[0]_11 NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16
+  NBL[0]_17 NBL[0]_18 NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23
+  NBL[0]_24 NBL[0]_25 NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30
+  NBL[0]_31 NBL[0]_32 NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1
+  NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9
+  NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16
+  NBL[1]_17 NBL[1]_18 NBL[1]_19 NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23
+  NBL[1]_24 NBL[1]_25 NBL[1]_26 NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30
+  NBL[1]_31 NBL[1]_32 NBL[1]_33 NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1
+  NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9
+  NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13 NBL[2]_14 NBL[2]_15 NBL[2]_16
+  NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20 NBL[2]_21 NBL[2]_22 NBL[2]_23
+  NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27 NBL[2]_28 NBL[2]_29 NBL[2]_30
+  NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34 NBL[2]_35 NBL[3]_0 NBL[3]_1
+  NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 NBL[3]_8 NBL[3]_9
+  NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13 NBL[3]_14 NBL[3]_15 NBL[3]_16
+  NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20 NBL[3]_21 NBL[3]_22 NBL[3]_23
+  NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27 NBL[3]_28 NBL[3]_29 NBL[3]_30
+  NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34 NBL[3]_35 VDDCE_0 VDDCE_1 VDDCE_2
+  VDDCE_3 VDDCE_4 VDDCE_5 VDDCE_6 VDDCE_7 VDDCE_8 VDDCE_9 VDDCE_10 VDDCE_11
+  VDDCE_12 VDDCE_13 VDDCE_14 VDDCE_15 VDDCE_16 VDDCE_17 VDDCE_18 VDDCE_19
+  VDDCE_20 VDDCE_21 VDDCE_22 VDDCE_23 VDDCE_24 VDDCE_25 VDDCE_26 VDDCE_27
+  VDDCE_28 VDDCE_29 VDDCE_30 VDDCE_31 VDDCE_32 VDDCE_33 VDDCE_34 VDDCE_35
+  VDDC_0 VDDC_1 VDDC_2 VDDC_3 VDDC_4 VDDC_5 VDDC_6 VDDC_7 VDDC_8 VDDC_9
+  VDDC_10 VDDC_11 VDDC_12 VDDC_13 VDDC_14 VDDC_15 VDDC_16 VDDC_17 VDDC_18
+  VDDC_19 VDDC_20 VDDC_21 VDDC_22 VDDC_23 VDDC_24 VDDC_25 VDDC_26 VDDC_27
+  VDDC_28 VDDC_29 VDDC_30 VDDC_31 VDDC_32 VDDC_33 VDDC_34 VDDC_35 VDDPE_0
+  VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8 VDDPE_9
+  VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16 VDDPE_17
+  VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24 VDDPE_25
+  VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32 VDDPE_33
+  VDDPE_34 VDDPE_35 VNWC_0 VNWC_1 VNWC_2 VNWC_3 VNWC_4 VNWC_5 VNWC_6 VNWC_7
+  VNWC_8 VNWC_9 VNWC_10 VNWC_11 VNWC_12 VNWC_13 VNWC_14 VNWC_15 VNWC_16
+  VNWC_17 VNWC_18 VNWC_19 VNWC_20 VNWC_21 VNWC_22 VNWC_23 VNWC_24 VNWC_25
+  VNWC_26 VNWC_27 VNWC_28 VNWC_29 VNWC_30 VNWC_31 VNWC_32 VNWC_33 VNWC_34
+  VNWC_35 VNWC_36 VNWC_37 VNWP_0 VNWP_1 VPW_0 VPW_1 VPW_2 VPW_3 VPW_4 VPW_5
+  VPW_6 VPW_7 VPW_8 VPW_9 VPW_10 VPW_11 VPW_12 VPW_13 VPW_14 VPW_15 VPW_16
+  VPW_17 VPW_18 VPW_19 VPW_20 VPW_21 VPW_22 VPW_23 VPW_24 VPW_25 VPW_26
+  VPW_27 VPW_28 VPW_29 VPW_30 VPW_31 VPW_32 VPW_33 VPW_34 VPW_35 VSSE WL[0]
+  WL[1]
** sram464x144MEM_L_TOP_ROW: 1732 flat devices **
XMEM_L_COL_1 BL[0]_1 BL[1]_1 BL[2]_1 BL[3]_1 CORED00_368 CORED01_370
+  CORED10_372 CORED11_374 CORED20_376 CORED21_378 CORED30_380 CORED31_382
+  NBL[0]_1 NBL[1]_1 NBL[2]_1 NBL[3]_1 NCORED00_384 NCORED01_386 NCORED10_388
+  NCORED11_390 NCORED20_392 NCORED21_394 NCORED30_396 NCORED31_398 VDDC_1
+  VDDCE_1 VDDPE_1 VNWC_2 VPW_1 VSSE WL[0] WL[1] sram464x144CCHD4
XMEM_L_COL_10 BL[0]_10 BL[1]_10 BL[2]_10 BL[3]_10 CORED00_656 CORED01_658
+  CORED10_660 CORED11_662 CORED20_664 CORED21_666 CORED30_668 CORED31_670
+  NBL[0]_10 NBL[1]_10 NBL[2]_10 NBL[3]_10 NCORED00_672 NCORED01_674
+  NCORED10_676 NCORED11_678 NCORED20_680 NCORED21_682 NCORED30_684
+  NCORED31_686 VDDC_10 VDDCE_10 VDDPE_10 VNWC_11 VPW_10 VSSE WL[0] WL[1]
+  sram464x144CCHD4
XMEM_L_COL_11 BL[0]_11 BL[1]_11 BL[2]_11 BL[3]_11 CORED00_688 CORED01_690
+  CORED10_692 CORED11_694 CORED20_696 CORED21_698 CORED30_700 CORED31_702
+  NBL[0]_11 NBL[1]_11 NBL[2]_11 NBL[3]_11 NCORED00_704 NCORED01_706
+  NCORED10_708 NCORED11_710 NCORED20_712 NCORED21_714 NCORED30_716
+  NCORED31_718 VDDC_11 VDDCE_11 VDDPE_11 VNWC_12 VPW_11 VSSE WL[0] WL[1]
+  sram464x144CCHD4
XMEM_L_COL_12 BL[0]_12 BL[1]_12 BL[2]_12 BL[3]_12 CORED00_752 CORED01_754
+  CORED10_756 CORED11_758 CORED20_760 CORED21_762 CORED30_764 CORED31_766
+  NBL[0]_12 NBL[1]_12 NBL[2]_12 NBL[3]_12 NCORED00_768 NCORED01_770
+  NCORED10_772 NCORED11_774 NCORED20_776 NCORED21_778 NCORED30_780
+  NCORED31_782 VDDC_12 VDDCE_12 VDDPE_12 VNWC_13 VPW_12 VSSE WL[0] WL[1]
+  sram464x144CCHD4
XMEM_L_COL_13 BL[0]_13 BL[1]_13 BL[2]_13 BL[3]_13 CORED00_816 CORED01_818
+  CORED10_820 CORED11_822 CORED20_824 CORED21_826 CORED30_828 CORED31_830
+  NBL[0]_13 NBL[1]_13 NBL[2]_13 NBL[3]_13 NCORED00_832 NCORED01_834
+  NCORED10_836 NCORED11_838 NCORED20_840 NCORED21_842 NCORED30_844
+  NCORED31_846 VDDC_13 VDDCE_13 VDDPE_13 VNWC_14 VPW_13 VSSE WL[0] WL[1]
+  sram464x144CCHD4
XMEM_L_COL_14 BL[0]_14 BL[1]_14 BL[2]_14 BL[3]_14 CORED00_880 CORED01_882
+  CORED10_884 CORED11_886 CORED20_888 CORED21_890 CORED30_892 CORED31_894
+  NBL[0]_14 NBL[1]_14 NBL[2]_14 NBL[3]_14 NCORED00_896 NCORED01_898
+  NCORED10_900 NCORED11_902 NCORED20_904 NCORED21_906 NCORED30_908
+  NCORED31_910 VDDC_14 VDDCE_14 VDDPE_14 VNWC_15 VPW_14 VSSE WL[0] WL[1]
+  sram464x144CCHD4
XMEM_L_COL_15 BL[0]_15 BL[1]_15 BL[2]_15 BL[3]_15 CORED00_944 CORED01_946
+  CORED10_948 CORED11_950 CORED20_952 CORED21_954 CORED30_956 CORED31_958
+  NBL[0]_15 NBL[1]_15 NBL[2]_15 NBL[3]_15 NCORED00_960 NCORED01_962
+  NCORED10_964 NCORED11_966 NCORED20_968 NCORED21_970 NCORED30_972
+  NCORED31_974 VDDC_15 VDDCE_15 VDDPE_15 VNWC_16 VPW_15 VSSE WL[0] WL[1]
+  sram464x144CCHD4
XMEM_L_COL_16 BL[0]_16 BL[1]_16 BL[2]_16 BL[3]_16 CORED00_1008 CORED01_1010
+  CORED10_1012 CORED11_1014 CORED20_1016 CORED21_1018 CORED30_1020
+  CORED31_1022 NBL[0]_16 NBL[1]_16 NBL[2]_16 NBL[3]_16 NCORED00_1024
+  NCORED01_1026 NCORED10_1028 NCORED11_1030 NCORED20_1032 NCORED21_1034
+  NCORED30_1036 NCORED31_1038 VDDC_16 VDDCE_16 VDDPE_16 VNWC_17 VPW_16 VSSE
+  WL[0] WL[1] sram464x144CCHD4
XMEM_L_COL_17 BL[0]_17 BL[1]_17 BL[2]_17 BL[3]_17 CORED00_1040 CORED01_1042
+  CORED10_1044 CORED11_1046 CORED20_1048 CORED21_1050 CORED30_1052
+  CORED31_1054 NBL[0]_17 NBL[1]_17 NBL[2]_17 NBL[3]_17 NCORED00_1056
+  NCORED01_1058 NCORED10_1060 NCORED11_1062 NCORED20_1064 NCORED21_1066
+  NCORED30_1068 NCORED31_1070 VDDC_17 VDDCE_17 VDDPE_17 VNWC_18 VPW_17 VSSE
+  WL[0] WL[1] sram464x144CCHD4
XMEM_L_COL_18 BL[0]_18 BL[1]_18 BL[2]_18 BL[3]_18 CORED00_1072 CORED01_1074
+  CORED10_1076 CORED11_1078 CORED20_1080 CORED21_1082 CORED30_1084
+  CORED31_1086 NBL[0]_18 NBL[1]_18 NBL[2]_18 NBL[3]_18 NCORED00_1088
+  NCORED01_1090 NCORED10_1092 NCORED11_1094 NCORED20_1096 NCORED21_1098
+  NCORED30_1100 NCORED31_1102 VDDC_18 VDDCE_18 VDDPE_18 VNWC_19 VPW_18 VSSE
+  WL[0] WL[1] sram464x144CCHD4
XMEM_L_COL_19 BL[0]_19 BL[1]_19 BL[2]_19 BL[3]_19 CORED00_1104 CORED01_1106
+  CORED10_1108 CORED11_1110 CORED20_1112 CORED21_1114 CORED30_1116
+  CORED31_1118 NBL[0]_19 NBL[1]_19 NBL[2]_19 NBL[3]_19 NCORED00_1120
+  NCORED01_1122 NCORED10_1124 NCORED11_1126 NCORED20_1128 NCORED21_1130
+  NCORED30_1132 NCORED31_1134 VDDC_19 VDDCE_19 VDDPE_19 VNWC_20 VPW_19 VSSE
+  WL[0] WL[1] sram464x144CCHD4
XMEM_L_COL_2 BL[0]_2 BL[1]_2 BL[2]_2 BL[3]_2 CORED00_400 CORED01_402
+  CORED10_404 CORED11_406 CORED20_408 CORED21_410 CORED30_412 CORED31_414
+  NBL[0]_2 NBL[1]_2 NBL[2]_2 NBL[3]_2 NCORED00_416 NCORED01_418 NCORED10_420
+  NCORED11_422 NCORED20_424 NCORED21_426 NCORED30_428 NCORED31_430 VDDC_2
+  VDDCE_2 VDDPE_2 VNWC_3 VPW_2 VSSE WL[0] WL[1] sram464x144CCHD4
XMEM_L_COL_20 BL[0]_20 BL[1]_20 BL[2]_20 BL[3]_20 CORED00_16 CORED01_18
+  CORED10_20 CORED11_22 CORED20_24 CORED21_26 CORED30_28 CORED31_30 NBL[0]_20
+  NBL[1]_20 NBL[2]_20 NBL[3]_20 NCORED00_32 NCORED01_34 NCORED10_36
+  NCORED11_38 NCORED20_40 NCORED21_42 NCORED30_44 NCORED31_46 VDDC_20
+  VDDCE_20 VDDPE_20 VNWC_21 VPW_20 VSSE WL[0] WL[1] sram464x144CCHD4
XMEM_L_COL_21 BL[0]_21 BL[1]_21 BL[2]_21 BL[3]_21 CORED00_48 CORED01_50
+  CORED10_52 CORED11_54 CORED20_56 CORED21_58 CORED30_60 CORED31_62 NBL[0]_21
+  NBL[1]_21 NBL[2]_21 NBL[3]_21 NCORED00_64 NCORED01_66 NCORED10_68
+  NCORED11_70 NCORED20_72 NCORED21_74 NCORED30_76 NCORED31_78 VDDC_21
+  VDDCE_21 VDDPE_21 VNWC_22 VPW_21 VSSE WL[0] WL[1] sram464x144CCHD4
XMEM_L_COL_22 BL[0]_22 BL[1]_22 BL[2]_22 BL[3]_22 CORED00_80 CORED01_82
+  CORED10_84 CORED11_86 CORED20_88 CORED21_90 CORED30_92 CORED31_94 NBL[0]_22
+  NBL[1]_22 NBL[2]_22 NBL[3]_22 NCORED00_96 NCORED01_98 NCORED10_100
+  NCORED11_102 NCORED20_104 NCORED21_106 NCORED30_108 NCORED31_110 VDDC_22
+  VDDCE_22 VDDPE_22 VNWC_23 VPW_22 VSSE WL[0] WL[1] sram464x144CCHD4
XMEM_L_COL_23 BL[0]_23 BL[1]_23 BL[2]_23 BL[3]_23 CORED00_144 CORED01_146
+  CORED10_148 CORED11_150 CORED20_152 CORED21_154 CORED30_156 CORED31_158
+  NBL[0]_23 NBL[1]_23 NBL[2]_23 NBL[3]_23 NCORED00_160 NCORED01_162
+  NCORED10_164 NCORED11_166 NCORED20_168 NCORED21_170 NCORED30_172
+  NCORED31_174 VDDC_23 VDDCE_23 VDDPE_23 VNWC_24 VPW_23 VSSE WL[0] WL[1]
+  sram464x144CCHD4
XMEM_L_COL_24 BL[0]_24 BL[1]_24 BL[2]_24 BL[3]_24 CORED00_176 CORED01_178
+  CORED10_180 CORED11_182 CORED20_184 CORED21_186 CORED30_188 CORED31_190
+  NBL[0]_24 NBL[1]_24 NBL[2]_24 NBL[3]_24 NCORED00_192 NCORED01_194
+  NCORED10_196 NCORED11_198 NCORED20_200 NCORED21_202 NCORED30_204
+  NCORED31_206 VDDC_24 VDDCE_24 VDDPE_24 VNWC_25 VPW_24 VSSE WL[0] WL[1]
+  sram464x144CCHD4
XMEM_L_COL_25 BL[0]_25 BL[1]_25 BL[2]_25 BL[3]_25 CORED00_208 CORED01_210
+  CORED10_212 CORED11_214 CORED20_216 CORED21_218 CORED30_220 CORED31_222
+  NBL[0]_25 NBL[1]_25 NBL[2]_25 NBL[3]_25 NCORED00_224 NCORED01_226
+  NCORED10_228 NCORED11_230 NCORED20_232 NCORED21_234 NCORED30_236
+  NCORED31_238 VDDC_25 VDDCE_25 VDDPE_25 VNWC_26 VPW_25 VSSE WL[0] WL[1]
+  sram464x144CCHD4
XMEM_L_COL_26 BL[0]_26 BL[1]_26 BL[2]_26 BL[3]_26 CORED00_240 CORED01_242
+  CORED10_244 CORED11_246 CORED20_248 CORED21_250 CORED30_252 CORED31_254
+  NBL[0]_26 NBL[1]_26 NBL[2]_26 NBL[3]_26 NCORED00_256 NCORED01_258
+  NCORED10_260 NCORED11_262 NCORED20_264 NCORED21_266 NCORED30_268
+  NCORED31_270 VDDC_26 VDDCE_26 VDDPE_26 VNWC_27 VPW_26 VSSE WL[0] WL[1]
+  sram464x144CCHD4
XMEM_L_COL_27 BL[0]_27 BL[1]_27 BL[2]_27 BL[3]_27 CORED00_272 CORED01_274
+  CORED10_276 CORED11_278 CORED20_280 CORED21_282 CORED30_284 CORED31_286
+  NBL[0]_27 NBL[1]_27 NBL[2]_27 NBL[3]_27 NCORED00_288 NCORED01_290
+  NCORED10_292 NCORED11_294 NCORED20_296 NCORED21_298 NCORED30_300
+  NCORED31_302 VDDC_27 VDDCE_27 VDDPE_27 VNWC_28 VPW_27 VSSE WL[0] WL[1]
+  sram464x144CCHD4
XMEM_L_COL_28 BL[0]_28 BL[1]_28 BL[2]_28 BL[3]_28 CORED00_304 CORED01_306
+  CORED10_308 CORED11_310 CORED20_312 CORED21_314 CORED30_316 CORED31_318
+  NBL[0]_28 NBL[1]_28 NBL[2]_28 NBL[3]_28 NCORED00_320 NCORED01_322
+  NCORED10_324 NCORED11_326 NCORED20_328 NCORED21_330 NCORED30_332
+  NCORED31_334 VDDC_28 VDDCE_28 VDDPE_28 VNWC_29 VPW_28 VSSE WL[0] WL[1]
+  sram464x144CCHD4
XMEM_L_COL_29 BL[0]_29 BL[1]_29 BL[2]_29 BL[3]_29 CORED00_336 CORED01_338
+  CORED10_340 CORED11_342 CORED20_344 CORED21_346 CORED30_348 CORED31_350
+  NBL[0]_29 NBL[1]_29 NBL[2]_29 NBL[3]_29 NCORED00_352 NCORED01_354
+  NCORED10_356 NCORED11_358 NCORED20_360 NCORED21_362 NCORED30_364
+  NCORED31_366 VDDC_29 VDDCE_29 VDDPE_29 VNWC_30 VPW_29 VSSE WL[0] WL[1]
+  sram464x144CCHD4
XMEM_L_COL_3 BL[0]_3 BL[1]_3 BL[2]_3 BL[3]_3 CORED00_432 CORED01_434
+  CORED10_436 CORED11_438 CORED20_440 CORED21_442 CORED30_444 CORED31_446
+  NBL[0]_3 NBL[1]_3 NBL[2]_3 NBL[3]_3 NCORED00_448 NCORED01_450 NCORED10_452
+  NCORED11_454 NCORED20_456 NCORED21_458 NCORED30_460 NCORED31_462 VDDC_3
+  VDDCE_3 VDDPE_3 VNWC_4 VPW_3 VSSE WL[0] WL[1] sram464x144CCHD4
XMEM_L_COL_30 BL[0]_30 BL[1]_30 BL[2]_30 BL[3]_30 CORED00_720 CORED01_722
+  CORED10_724 CORED11_726 CORED20_728 CORED21_730 CORED30_732 CORED31_734
+  NBL[0]_30 NBL[1]_30 NBL[2]_30 NBL[3]_30 NCORED00_736 NCORED01_738
+  NCORED10_740 NCORED11_742 NCORED20_744 NCORED21_746 NCORED30_748
+  NCORED31_750 VDDC_30 VDDCE_30 VDDPE_30 VNWC_31 VPW_30 VSSE WL[0] WL[1]
+  sram464x144CCHD4
XMEM_L_COL_31 BL[0]_31 BL[1]_31 BL[2]_31 BL[3]_31 CORED00_784 CORED01_786
+  CORED10_788 CORED11_790 CORED20_792 CORED21_794 CORED30_796 CORED31_798
+  NBL[0]_31 NBL[1]_31 NBL[2]_31 NBL[3]_31 NCORED00_800 NCORED01_802
+  NCORED10_804 NCORED11_806 NCORED20_808 NCORED21_810 NCORED30_812
+  NCORED31_814 VDDC_31 VDDCE_31 VDDPE_31 VNWC_32 VPW_31 VSSE WL[0] WL[1]
+  sram464x144CCHD4
XMEM_L_COL_32 BL[0]_32 BL[1]_32 BL[2]_32 BL[3]_32 CORED00_848 CORED01_850
+  CORED10_852 CORED11_854 CORED20_856 CORED21_858 CORED30_860 CORED31_862
+  NBL[0]_32 NBL[1]_32 NBL[2]_32 NBL[3]_32 NCORED00_864 NCORED01_866
+  NCORED10_868 NCORED11_870 NCORED20_872 NCORED21_874 NCORED30_876
+  NCORED31_878 VDDC_32 VDDCE_32 VDDPE_32 VNWC_33 VPW_32 VSSE WL[0] WL[1]
+  sram464x144CCHD4
XMEM_L_COL_33 BL[0]_33 BL[1]_33 BL[2]_33 BL[3]_33 CORED00_912 CORED01_914
+  CORED10_916 CORED11_918 CORED20_920 CORED21_922 CORED30_924 CORED31_926
+  NBL[0]_33 NBL[1]_33 NBL[2]_33 NBL[3]_33 NCORED00_928 NCORED01_930
+  NCORED10_932 NCORED11_934 NCORED20_936 NCORED21_938 NCORED30_940
+  NCORED31_942 VDDC_33 VDDCE_33 VDDPE_33 VNWC_34 VPW_33 VSSE WL[0] WL[1]
+  sram464x144CCHD4
XMEM_L_COL_34 BL[0]_34 BL[1]_34 BL[2]_34 BL[3]_34 CORED00_976 CORED01_978
+  CORED10_980 CORED11_982 CORED20_984 CORED21_986 CORED30_988 CORED31_990
+  NBL[0]_34 NBL[1]_34 NBL[2]_34 NBL[3]_34 NCORED00_992 NCORED01_994
+  NCORED10_996 NCORED11_998 NCORED20_1000 NCORED21_1002 NCORED30_1004
+  NCORED31_1006 VDDC_34 VDDCE_34 VDDPE_34 VNWC_35 VPW_34 VSSE WL[0] WL[1]
+  sram464x144CCHD4
XMEM_L_COL_4 BL[0]_4 BL[1]_4 BL[2]_4 BL[3]_4 CORED00_464 CORED01_466
+  CORED10_468 CORED11_470 CORED20_472 CORED21_474 CORED30_476 CORED31_478
+  NBL[0]_4 NBL[1]_4 NBL[2]_4 NBL[3]_4 NCORED00_480 NCORED01_482 NCORED10_484
+  NCORED11_486 NCORED20_488 NCORED21_490 NCORED30_492 NCORED31_494 VDDC_4
+  VDDCE_4 VDDPE_4 VNWC_5 VPW_4 VSSE WL[0] WL[1] sram464x144CCHD4
XMEM_L_COL_5 BL[0]_5 BL[1]_5 BL[2]_5 BL[3]_5 CORED00_496 CORED01_498
+  CORED10_500 CORED11_502 CORED20_504 CORED21_506 CORED30_508 CORED31_510
+  NBL[0]_5 NBL[1]_5 NBL[2]_5 NBL[3]_5 NCORED00_512 NCORED01_514 NCORED10_516
+  NCORED11_518 NCORED20_520 NCORED21_522 NCORED30_524 NCORED31_526 VDDC_5
+  VDDCE_5 VDDPE_5 VNWC_6 VPW_5 VSSE WL[0] WL[1] sram464x144CCHD4
XMEM_L_COL_6 BL[0]_6 BL[1]_6 BL[2]_6 BL[3]_6 CORED00_528 CORED01_530
+  CORED10_532 CORED11_534 CORED20_536 CORED21_538 CORED30_540 CORED31_542
+  NBL[0]_6 NBL[1]_6 NBL[2]_6 NBL[3]_6 NCORED00_544 NCORED01_546 NCORED10_548
+  NCORED11_550 NCORED20_552 NCORED21_554 NCORED30_556 NCORED31_558 VDDC_6
+  VDDCE_6 VDDPE_6 VNWC_7 VPW_6 VSSE WL[0] WL[1] sram464x144CCHD4
XMEM_L_COL_7 BL[0]_7 BL[1]_7 BL[2]_7 BL[3]_7 CORED00_560 CORED01_562
+  CORED10_564 CORED11_566 CORED20_568 CORED21_570 CORED30_572 CORED31_574
+  NBL[0]_7 NBL[1]_7 NBL[2]_7 NBL[3]_7 NCORED00_576 NCORED01_578 NCORED10_580
+  NCORED11_582 NCORED20_584 NCORED21_586 NCORED30_588 NCORED31_590 VDDC_7
+  VDDCE_7 VDDPE_7 VNWC_8 VPW_7 VSSE WL[0] WL[1] sram464x144CCHD4
XMEM_L_COL_8 BL[0]_8 BL[1]_8 BL[2]_8 BL[3]_8 CORED00_592 CORED01_594
+  CORED10_596 CORED11_598 CORED20_600 CORED21_602 CORED30_604 CORED31_606
+  NBL[0]_8 NBL[1]_8 NBL[2]_8 NBL[3]_8 NCORED00_608 NCORED01_610 NCORED10_612
+  NCORED11_614 NCORED20_616 NCORED21_618 NCORED30_620 NCORED31_622 VDDC_8
+  VDDCE_8 VDDPE_8 VNWC_9 VPW_8 VSSE WL[0] WL[1] sram464x144CCHD4
XMEM_L_COL_9 BL[0]_9 BL[1]_9 BL[2]_9 BL[3]_9 CORED00_624 CORED01_626
+  CORED10_628 CORED11_630 CORED20_632 CORED21_634 CORED30_636 CORED31_638
+  NBL[0]_9 NBL[1]_9 NBL[2]_9 NBL[3]_9 NCORED00_640 NCORED01_642 NCORED10_644
+  NCORED11_646 NCORED20_648 NCORED21_650 NCORED30_652 NCORED31_654 VDDC_9
+  VDDCE_9 VDDPE_9 VNWC_10 VPW_9 VSSE WL[0] WL[1] sram464x144CCHD4
XMEM_L_COL_EDGEL VNWC_0 VNWP_0 VSSE VSSE WL[0] WL[1] sram464x144CCHD4_EDG
XMEM_L_COL_EDGER VNWC_37 VNWP_1 VSSE VSSE WL[0] WL[1] sram464x144CCHD4WD_EDG
XMEM_L_COL_TOP_L BL[0]_0 BL[1]_0 BL[2]_0 BL[3]_0 CORED00 CORED01 CORED10
+  CORED11 CORED20 CORED21 CORED30 CORED31 NBL[0]_0 NBL[1]_0 NBL[2]_0 NBL[3]_0
+  NCORED00 NCORED01 NCORED10 NCORED11 NCORED20 NCORED21 NCORED30 NCORED31
+  VDDC_0 VDDCE_0 VDDPE_0 VNWC_1 VPW_0 VSSE WL[0] WL[1] sram464x144CCHD4
XMEM_L_COL_TOP_R BL[0]_35 BL[1]_35 BL[2]_35 BL[3]_35 CORED00_112 CORED01_114
+  CORED10_116 CORED11_118 CORED20_120 CORED21_122 CORED30_124 CORED31_126
+  NBL[0]_35 NBL[1]_35 NBL[2]_35 NBL[3]_35 NCORED00_128 NCORED01_130
+  NCORED10_132 NCORED11_134 NCORED20_136 NCORED21_138 NCORED30_140
+  NCORED31_142 VDDC_35 VDDCE_35 VDDPE_35 VNWC_36 VPW_35 VSSE WL[0] WL[1]
+  sram464x144CCHD4
.ENDS sram464x144MEM_L_TOP_ROW
****
.SUBCKT sram464x144MEM_L_MIDB_ROW BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4
+  BL[0]_5 BL[0]_6 BL[0]_7 BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13
+  BL[0]_14 BL[0]_15 BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21
+  BL[0]_22 BL[0]_23 BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29
+  BL[0]_30 BL[0]_31 BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1
+  BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10
+  BL[1]_11 BL[1]_12 BL[1]_13 BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18
+  BL[1]_19 BL[1]_20 BL[1]_21 BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26
+  BL[1]_27 BL[1]_28 BL[1]_29 BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34
+  BL[1]_35 BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7
+  BL[2]_8 BL[2]_9 BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15
+  BL[2]_16 BL[2]_17 BL[2]_18 BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23
+  BL[2]_24 BL[2]_25 BL[2]_26 BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31
+  BL[2]_32 BL[2]_33 BL[2]_34 BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4
+  BL[3]_5 BL[3]_6 BL[3]_7 BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13
+  BL[3]_14 BL[3]_15 BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21
+  BL[3]_22 BL[3]_23 BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29
+  BL[3]_30 BL[3]_31 BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1
+  NBL[0]_2 NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9
+  NBL[0]_10 NBL[0]_11 NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16
+  NBL[0]_17 NBL[0]_18 NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23
+  NBL[0]_24 NBL[0]_25 NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30
+  NBL[0]_31 NBL[0]_32 NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1
+  NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9
+  NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16
+  NBL[1]_17 NBL[1]_18 NBL[1]_19 NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23
+  NBL[1]_24 NBL[1]_25 NBL[1]_26 NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30
+  NBL[1]_31 NBL[1]_32 NBL[1]_33 NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1
+  NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9
+  NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13 NBL[2]_14 NBL[2]_15 NBL[2]_16
+  NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20 NBL[2]_21 NBL[2]_22 NBL[2]_23
+  NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27 NBL[2]_28 NBL[2]_29 NBL[2]_30
+  NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34 NBL[2]_35 NBL[3]_0 NBL[3]_1
+  NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 NBL[3]_8 NBL[3]_9
+  NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13 NBL[3]_14 NBL[3]_15 NBL[3]_16
+  NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20 NBL[3]_21 NBL[3]_22 NBL[3]_23
+  NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27 NBL[3]_28 NBL[3]_29 NBL[3]_30
+  NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34 NBL[3]_35 VDDCE_0 VDDCE_1 VDDCE_2
+  VDDCE_3 VDDCE_4 VDDCE_5 VDDCE_6 VDDCE_7 VDDCE_8 VDDCE_9 VDDCE_10 VDDCE_11
+  VDDCE_12 VDDCE_13 VDDCE_14 VDDCE_15 VDDCE_16 VDDCE_17 VDDCE_18 VDDCE_19
+  VDDCE_20 VDDCE_21 VDDCE_22 VDDCE_23 VDDCE_24 VDDCE_25 VDDCE_26 VDDCE_27
+  VDDCE_28 VDDCE_29 VDDCE_30 VDDCE_31 VDDCE_32 VDDCE_33 VDDCE_34 VDDCE_35
+  VDDC_0 VDDC_1 VDDC_2 VDDC_3 VDDC_4 VDDC_5 VDDC_6 VDDC_7 VDDC_8 VDDC_9
+  VDDC_10 VDDC_11 VDDC_12 VDDC_13 VDDC_14 VDDC_15 VDDC_16 VDDC_17 VDDC_18
+  VDDC_19 VDDC_20 VDDC_21 VDDC_22 VDDC_23 VDDC_24 VDDC_25 VDDC_26 VDDC_27
+  VDDC_28 VDDC_29 VDDC_30 VDDC_31 VDDC_32 VDDC_33 VDDC_34 VDDC_35 VDDPE_0
+  VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8 VDDPE_9
+  VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16 VDDPE_17
+  VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24 VDDPE_25
+  VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32 VDDPE_33
+  VDDPE_34 VDDPE_35 VNWC_0 VNWC_1 VNWC_2 VNWC_3 VNWC_4 VNWC_5 VNWC_6 VNWC_7
+  VNWC_8 VNWC_9 VNWC_10 VNWC_11 VNWC_12 VNWC_13 VNWC_14 VNWC_15 VNWC_16
+  VNWC_17 VNWC_18 VNWC_19 VNWC_20 VNWC_21 VNWC_22 VNWC_23 VNWC_24 VNWC_25
+  VNWC_26 VNWC_27 VNWC_28 VNWC_29 VNWC_30 VNWC_31 VNWC_32 VNWC_33 VNWC_34
+  VNWC_35 VNWC_36 VNWC_37 VNWP_0 VNWP_1 VPW_0 VPW_1 VPW_2 VPW_3 VPW_4 VPW_5
+  VPW_6 VPW_7 VPW_8 VPW_9 VPW_10 VPW_11 VPW_12 VPW_13 VPW_14 VPW_15 VPW_16
+  VPW_17 VPW_18 VPW_19 VPW_20 VPW_21 VPW_22 VPW_23 VPW_24 VPW_25 VPW_26
+  VPW_27 VPW_28 VPW_29 VPW_30 VPW_31 VPW_32 VPW_33 VPW_34 VPW_35 VSSE WL[0]
+  WL[1]
** sram464x144MEM_L_MIDB_ROW: 1732 flat devices **
XMEM_L_COL_0 BL[0]_0 BL[1]_0 BL[2]_0 BL[3]_0 CORED00_304 CORED01_306
+  CORED10_308 CORED11_310 CORED20_312 CORED21_314 CORED30_316 CORED31_318
+  NBL[0]_0 NBL[1]_0 NBL[2]_0 NBL[3]_0 NCORED00_320 NCORED01_322 NCORED10_324
+  NCORED11_326 NCORED20_328 NCORED21_330 NCORED30_332 NCORED31_334 VDDC_0
+  VDDCE_0 VDDPE_0 VNWC_1 VPW_0 VSSE WL[0] WL[1] sram464x144CCHD4
XMEM_L_COL_1 BL[0]_1 BL[1]_1 BL[2]_1 BL[3]_1 CORED00_336 CORED01_338
+  CORED10_340 CORED11_342 CORED20_344 CORED21_346 CORED30_348 CORED31_350
+  NBL[0]_1 NBL[1]_1 NBL[2]_1 NBL[3]_1 NCORED00_352 NCORED01_354 NCORED10_356
+  NCORED11_358 NCORED20_360 NCORED21_362 NCORED30_364 NCORED31_366 VDDC_1
+  VDDCE_1 VDDPE_1 VNWC_2 VPW_1 VSSE WL[0] WL[1] sram464x144CCHD4
XMEM_L_COL_10 BL[0]_10 BL[1]_10 BL[2]_10 BL[3]_10 CORED00_624 CORED01_626
+  CORED10_628 CORED11_630 CORED20_632 CORED21_634 CORED30_636 CORED31_638
+  NBL[0]_10 NBL[1]_10 NBL[2]_10 NBL[3]_10 NCORED00_640 NCORED01_642
+  NCORED10_644 NCORED11_646 NCORED20_648 NCORED21_650 NCORED30_652
+  NCORED31_654 VDDC_10 VDDCE_10 VDDPE_10 VNWC_11 VPW_10 VSSE WL[0] WL[1]
+  sram464x144CCHD4
XMEM_L_COL_11 BL[0]_11 BL[1]_11 BL[2]_11 BL[3]_11 CORED00_656 CORED01_658
+  CORED10_660 CORED11_662 CORED20_664 CORED21_666 CORED30_668 CORED31_670
+  NBL[0]_11 NBL[1]_11 NBL[2]_11 NBL[3]_11 NCORED00_672 NCORED01_674
+  NCORED10_676 NCORED11_678 NCORED20_680 NCORED21_682 NCORED30_684
+  NCORED31_686 VDDC_11 VDDCE_11 VDDPE_11 VNWC_12 VPW_11 VSSE WL[0] WL[1]
+  sram464x144CCHD4
XMEM_L_COL_12 BL[0]_12 BL[1]_12 BL[2]_12 BL[3]_12 CORED00_720 CORED01_722
+  CORED10_724 CORED11_726 CORED20_728 CORED21_730 CORED30_732 CORED31_734
+  NBL[0]_12 NBL[1]_12 NBL[2]_12 NBL[3]_12 NCORED00_736 NCORED01_738
+  NCORED10_740 NCORED11_742 NCORED20_744 NCORED21_746 NCORED30_748
+  NCORED31_750 VDDC_12 VDDCE_12 VDDPE_12 VNWC_13 VPW_12 VSSE WL[0] WL[1]
+  sram464x144CCHD4
XMEM_L_COL_13 BL[0]_13 BL[1]_13 BL[2]_13 BL[3]_13 CORED00_784 CORED01_786
+  CORED10_788 CORED11_790 CORED20_792 CORED21_794 CORED30_796 CORED31_798
+  NBL[0]_13 NBL[1]_13 NBL[2]_13 NBL[3]_13 NCORED00_800 NCORED01_802
+  NCORED10_804 NCORED11_806 NCORED20_808 NCORED21_810 NCORED30_812
+  NCORED31_814 VDDC_13 VDDCE_13 VDDPE_13 VNWC_14 VPW_13 VSSE WL[0] WL[1]
+  sram464x144CCHD4
XMEM_L_COL_14 BL[0]_14 BL[1]_14 BL[2]_14 BL[3]_14 CORED00_848 CORED01_850
+  CORED10_852 CORED11_854 CORED20_856 CORED21_858 CORED30_860 CORED31_862
+  NBL[0]_14 NBL[1]_14 NBL[2]_14 NBL[3]_14 NCORED00_864 NCORED01_866
+  NCORED10_868 NCORED11_870 NCORED20_872 NCORED21_874 NCORED30_876
+  NCORED31_878 VDDC_14 VDDCE_14 VDDPE_14 VNWC_15 VPW_14 VSSE WL[0] WL[1]
+  sram464x144CCHD4
XMEM_L_COL_15 BL[0]_15 BL[1]_15 BL[2]_15 BL[3]_15 CORED00_912 CORED01_914
+  CORED10_916 CORED11_918 CORED20_920 CORED21_922 CORED30_924 CORED31_926
+  NBL[0]_15 NBL[1]_15 NBL[2]_15 NBL[3]_15 NCORED00_928 NCORED01_930
+  NCORED10_932 NCORED11_934 NCORED20_936 NCORED21_938 NCORED30_940
+  NCORED31_942 VDDC_15 VDDCE_15 VDDPE_15 VNWC_16 VPW_15 VSSE WL[0] WL[1]
+  sram464x144CCHD4
XMEM_L_COL_16 BL[0]_16 BL[1]_16 BL[2]_16 BL[3]_16 CORED00_976 CORED01_978
+  CORED10_980 CORED11_982 CORED20_984 CORED21_986 CORED30_988 CORED31_990
+  NBL[0]_16 NBL[1]_16 NBL[2]_16 NBL[3]_16 NCORED00_992 NCORED01_994
+  NCORED10_996 NCORED11_998 NCORED20_1000 NCORED21_1002 NCORED30_1004
+  NCORED31_1006 VDDC_16 VDDCE_16 VDDPE_16 VNWC_17 VPW_16 VSSE WL[0] WL[1]
+  sram464x144CCHD4
XMEM_L_COL_17 BL[0]_17 BL[1]_17 BL[2]_17 BL[3]_17 CORED00_1040 CORED01_1042
+  CORED10_1044 CORED11_1046 CORED20_1048 CORED21_1050 CORED30_1052
+  CORED31_1054 NBL[0]_17 NBL[1]_17 NBL[2]_17 NBL[3]_17 NCORED00_1056
+  NCORED01_1058 NCORED10_1060 NCORED11_1062 NCORED20_1064 NCORED21_1066
+  NCORED30_1068 NCORED31_1070 VDDC_17 VDDCE_17 VDDPE_17 VNWC_18 VPW_17 VSSE
+  WL[0] WL[1] sram464x144CCHD4
XMEM_L_COL_18 BL[0]_18 BL[1]_18 BL[2]_18 BL[3]_18 CORED00_1072 CORED01_1074
+  CORED10_1076 CORED11_1078 CORED20_1080 CORED21_1082 CORED30_1084
+  CORED31_1086 NBL[0]_18 NBL[1]_18 NBL[2]_18 NBL[3]_18 NCORED00_1088
+  NCORED01_1090 NCORED10_1092 NCORED11_1094 NCORED20_1096 NCORED21_1098
+  NCORED30_1100 NCORED31_1102 VDDC_18 VDDCE_18 VDDPE_18 VNWC_19 VPW_18 VSSE
+  WL[0] WL[1] sram464x144CCHD4
XMEM_L_COL_19 BL[0]_19 BL[1]_19 BL[2]_19 BL[3]_19 CORED00_1104 CORED01_1106
+  CORED10_1108 CORED11_1110 CORED20_1112 CORED21_1114 CORED30_1116
+  CORED31_1118 NBL[0]_19 NBL[1]_19 NBL[2]_19 NBL[3]_19 NCORED00_1120
+  NCORED01_1122 NCORED10_1124 NCORED11_1126 NCORED20_1128 NCORED21_1130
+  NCORED30_1132 NCORED31_1134 VDDC_19 VDDCE_19 VDDPE_19 VNWC_20 VPW_19 VSSE
+  WL[0] WL[1] sram464x144CCHD4
XMEM_L_COL_2 BL[0]_2 BL[1]_2 BL[2]_2 BL[3]_2 CORED00_368 CORED01_370
+  CORED10_372 CORED11_374 CORED20_376 CORED21_378 CORED30_380 CORED31_382
+  NBL[0]_2 NBL[1]_2 NBL[2]_2 NBL[3]_2 NCORED00_384 NCORED01_386 NCORED10_388
+  NCORED11_390 NCORED20_392 NCORED21_394 NCORED30_396 NCORED31_398 VDDC_2
+  VDDCE_2 VDDPE_2 VNWC_3 VPW_2 VSSE WL[0] WL[1] sram464x144CCHD4
XMEM_L_COL_20 BL[0]_20 BL[1]_20 BL[2]_20 BL[3]_20 CORED00 CORED01 CORED10
+  CORED11 CORED20 CORED21 CORED30 CORED31 NBL[0]_20 NBL[1]_20 NBL[2]_20
+  NBL[3]_20 NCORED00 NCORED01 NCORED10 NCORED11 NCORED20 NCORED21 NCORED30
+  NCORED31 VDDC_20 VDDCE_20 VDDPE_20 VNWC_21 VPW_20 VSSE WL[0] WL[1]
+  sram464x144CCHD4
XMEM_L_COL_21 BL[0]_21 BL[1]_21 BL[2]_21 BL[3]_21 CORED00_16 CORED01_18
+  CORED10_20 CORED11_22 CORED20_24 CORED21_26 CORED30_28 CORED31_30 NBL[0]_21
+  NBL[1]_21 NBL[2]_21 NBL[3]_21 NCORED00_32 NCORED01_34 NCORED10_36
+  NCORED11_38 NCORED20_40 NCORED21_42 NCORED30_44 NCORED31_46 VDDC_21
+  VDDCE_21 VDDPE_21 VNWC_22 VPW_21 VSSE WL[0] WL[1] sram464x144CCHD4
XMEM_L_COL_22 BL[0]_22 BL[1]_22 BL[2]_22 BL[3]_22 CORED00_48 CORED01_50
+  CORED10_52 CORED11_54 CORED20_56 CORED21_58 CORED30_60 CORED31_62 NBL[0]_22
+  NBL[1]_22 NBL[2]_22 NBL[3]_22 NCORED00_64 NCORED01_66 NCORED10_68
+  NCORED11_70 NCORED20_72 NCORED21_74 NCORED30_76 NCORED31_78 VDDC_22
+  VDDCE_22 VDDPE_22 VNWC_23 VPW_22 VSSE WL[0] WL[1] sram464x144CCHD4
XMEM_L_COL_23 BL[0]_23 BL[1]_23 BL[2]_23 BL[3]_23 CORED00_80 CORED01_82
+  CORED10_84 CORED11_86 CORED20_88 CORED21_90 CORED30_92 CORED31_94 NBL[0]_23
+  NBL[1]_23 NBL[2]_23 NBL[3]_23 NCORED00_96 NCORED01_98 NCORED10_100
+  NCORED11_102 NCORED20_104 NCORED21_106 NCORED30_108 NCORED31_110 VDDC_23
+  VDDCE_23 VDDPE_23 VNWC_24 VPW_23 VSSE WL[0] WL[1] sram464x144CCHD4
XMEM_L_COL_24 BL[0]_24 BL[1]_24 BL[2]_24 BL[3]_24 CORED00_112 CORED01_114
+  CORED10_116 CORED11_118 CORED20_120 CORED21_122 CORED30_124 CORED31_126
+  NBL[0]_24 NBL[1]_24 NBL[2]_24 NBL[3]_24 NCORED00_128 NCORED01_130
+  NCORED10_132 NCORED11_134 NCORED20_136 NCORED21_138 NCORED30_140
+  NCORED31_142 VDDC_24 VDDCE_24 VDDPE_24 VNWC_25 VPW_24 VSSE WL[0] WL[1]
+  sram464x144CCHD4
XMEM_L_COL_25 BL[0]_25 BL[1]_25 BL[2]_25 BL[3]_25 CORED00_144 CORED01_146
+  CORED10_148 CORED11_150 CORED20_152 CORED21_154 CORED30_156 CORED31_158
+  NBL[0]_25 NBL[1]_25 NBL[2]_25 NBL[3]_25 NCORED00_160 NCORED01_162
+  NCORED10_164 NCORED11_166 NCORED20_168 NCORED21_170 NCORED30_172
+  NCORED31_174 VDDC_25 VDDCE_25 VDDPE_25 VNWC_26 VPW_25 VSSE WL[0] WL[1]
+  sram464x144CCHD4
XMEM_L_COL_26 BL[0]_26 BL[1]_26 BL[2]_26 BL[3]_26 CORED00_176 CORED01_178
+  CORED10_180 CORED11_182 CORED20_184 CORED21_186 CORED30_188 CORED31_190
+  NBL[0]_26 NBL[1]_26 NBL[2]_26 NBL[3]_26 NCORED00_192 NCORED01_194
+  NCORED10_196 NCORED11_198 NCORED20_200 NCORED21_202 NCORED30_204
+  NCORED31_206 VDDC_26 VDDCE_26 VDDPE_26 VNWC_27 VPW_26 VSSE WL[0] WL[1]
+  sram464x144CCHD4
XMEM_L_COL_27 BL[0]_27 BL[1]_27 BL[2]_27 BL[3]_27 CORED00_208 CORED01_210
+  CORED10_212 CORED11_214 CORED20_216 CORED21_218 CORED30_220 CORED31_222
+  NBL[0]_27 NBL[1]_27 NBL[2]_27 NBL[3]_27 NCORED00_224 NCORED01_226
+  NCORED10_228 NCORED11_230 NCORED20_232 NCORED21_234 NCORED30_236
+  NCORED31_238 VDDC_27 VDDCE_27 VDDPE_27 VNWC_28 VPW_27 VSSE WL[0] WL[1]
+  sram464x144CCHD4
XMEM_L_COL_28 BL[0]_28 BL[1]_28 BL[2]_28 BL[3]_28 CORED00_240 CORED01_242
+  CORED10_244 CORED11_246 CORED20_248 CORED21_250 CORED30_252 CORED31_254
+  NBL[0]_28 NBL[1]_28 NBL[2]_28 NBL[3]_28 NCORED00_256 NCORED01_258
+  NCORED10_260 NCORED11_262 NCORED20_264 NCORED21_266 NCORED30_268
+  NCORED31_270 VDDC_28 VDDCE_28 VDDPE_28 VNWC_29 VPW_28 VSSE WL[0] WL[1]
+  sram464x144CCHD4
XMEM_L_COL_29 BL[0]_29 BL[1]_29 BL[2]_29 BL[3]_29 CORED00_272 CORED01_274
+  CORED10_276 CORED11_278 CORED20_280 CORED21_282 CORED30_284 CORED31_286
+  NBL[0]_29 NBL[1]_29 NBL[2]_29 NBL[3]_29 NCORED00_288 NCORED01_290
+  NCORED10_292 NCORED11_294 NCORED20_296 NCORED21_298 NCORED30_300
+  NCORED31_302 VDDC_29 VDDCE_29 VDDPE_29 VNWC_30 VPW_29 VSSE WL[0] WL[1]
+  sram464x144CCHD4
XMEM_L_COL_3 BL[0]_3 BL[1]_3 BL[2]_3 BL[3]_3 CORED00_400 CORED01_402
+  CORED10_404 CORED11_406 CORED20_408 CORED21_410 CORED30_412 CORED31_414
+  NBL[0]_3 NBL[1]_3 NBL[2]_3 NBL[3]_3 NCORED00_416 NCORED01_418 NCORED10_420
+  NCORED11_422 NCORED20_424 NCORED21_426 NCORED30_428 NCORED31_430 VDDC_3
+  VDDCE_3 VDDPE_3 VNWC_4 VPW_3 VSSE WL[0] WL[1] sram464x144CCHD4
XMEM_L_COL_30 BL[0]_30 BL[1]_30 BL[2]_30 BL[3]_30 CORED00_688 CORED01_690
+  CORED10_692 CORED11_694 CORED20_696 CORED21_698 CORED30_700 CORED31_702
+  NBL[0]_30 NBL[1]_30 NBL[2]_30 NBL[3]_30 NCORED00_704 NCORED01_706
+  NCORED10_708 NCORED11_710 NCORED20_712 NCORED21_714 NCORED30_716
+  NCORED31_718 VDDC_30 VDDCE_30 VDDPE_30 VNWC_31 VPW_30 VSSE WL[0] WL[1]
+  sram464x144CCHD4
XMEM_L_COL_31 BL[0]_31 BL[1]_31 BL[2]_31 BL[3]_31 CORED00_752 CORED01_754
+  CORED10_756 CORED11_758 CORED20_760 CORED21_762 CORED30_764 CORED31_766
+  NBL[0]_31 NBL[1]_31 NBL[2]_31 NBL[3]_31 NCORED00_768 NCORED01_770
+  NCORED10_772 NCORED11_774 NCORED20_776 NCORED21_778 NCORED30_780
+  NCORED31_782 VDDC_31 VDDCE_31 VDDPE_31 VNWC_32 VPW_31 VSSE WL[0] WL[1]
+  sram464x144CCHD4
XMEM_L_COL_32 BL[0]_32 BL[1]_32 BL[2]_32 BL[3]_32 CORED00_816 CORED01_818
+  CORED10_820 CORED11_822 CORED20_824 CORED21_826 CORED30_828 CORED31_830
+  NBL[0]_32 NBL[1]_32 NBL[2]_32 NBL[3]_32 NCORED00_832 NCORED01_834
+  NCORED10_836 NCORED11_838 NCORED20_840 NCORED21_842 NCORED30_844
+  NCORED31_846 VDDC_32 VDDCE_32 VDDPE_32 VNWC_33 VPW_32 VSSE WL[0] WL[1]
+  sram464x144CCHD4
XMEM_L_COL_33 BL[0]_33 BL[1]_33 BL[2]_33 BL[3]_33 CORED00_880 CORED01_882
+  CORED10_884 CORED11_886 CORED20_888 CORED21_890 CORED30_892 CORED31_894
+  NBL[0]_33 NBL[1]_33 NBL[2]_33 NBL[3]_33 NCORED00_896 NCORED01_898
+  NCORED10_900 NCORED11_902 NCORED20_904 NCORED21_906 NCORED30_908
+  NCORED31_910 VDDC_33 VDDCE_33 VDDPE_33 VNWC_34 VPW_33 VSSE WL[0] WL[1]
+  sram464x144CCHD4
XMEM_L_COL_34 BL[0]_34 BL[1]_34 BL[2]_34 BL[3]_34 CORED00_944 CORED01_946
+  CORED10_948 CORED11_950 CORED20_952 CORED21_954 CORED30_956 CORED31_958
+  NBL[0]_34 NBL[1]_34 NBL[2]_34 NBL[3]_34 NCORED00_960 NCORED01_962
+  NCORED10_964 NCORED11_966 NCORED20_968 NCORED21_970 NCORED30_972
+  NCORED31_974 VDDC_34 VDDCE_34 VDDPE_34 VNWC_35 VPW_34 VSSE WL[0] WL[1]
+  sram464x144CCHD4
XMEM_L_COL_35 BL[0]_35 BL[1]_35 BL[2]_35 BL[3]_35 CORED00_1008 CORED01_1010
+  CORED10_1012 CORED11_1014 CORED20_1016 CORED21_1018 CORED30_1020
+  CORED31_1022 NBL[0]_35 NBL[1]_35 NBL[2]_35 NBL[3]_35 NCORED00_1024
+  NCORED01_1026 NCORED10_1028 NCORED11_1030 NCORED20_1032 NCORED21_1034
+  NCORED30_1036 NCORED31_1038 VDDC_35 VDDCE_35 VDDPE_35 VNWC_36 VPW_35 VSSE
+  WL[0] WL[1] sram464x144CCHD4
XMEM_L_COL_4 BL[0]_4 BL[1]_4 BL[2]_4 BL[3]_4 CORED00_432 CORED01_434
+  CORED10_436 CORED11_438 CORED20_440 CORED21_442 CORED30_444 CORED31_446
+  NBL[0]_4 NBL[1]_4 NBL[2]_4 NBL[3]_4 NCORED00_448 NCORED01_450 NCORED10_452
+  NCORED11_454 NCORED20_456 NCORED21_458 NCORED30_460 NCORED31_462 VDDC_4
+  VDDCE_4 VDDPE_4 VNWC_5 VPW_4 VSSE WL[0] WL[1] sram464x144CCHD4
XMEM_L_COL_5 BL[0]_5 BL[1]_5 BL[2]_5 BL[3]_5 CORED00_464 CORED01_466
+  CORED10_468 CORED11_470 CORED20_472 CORED21_474 CORED30_476 CORED31_478
+  NBL[0]_5 NBL[1]_5 NBL[2]_5 NBL[3]_5 NCORED00_480 NCORED01_482 NCORED10_484
+  NCORED11_486 NCORED20_488 NCORED21_490 NCORED30_492 NCORED31_494 VDDC_5
+  VDDCE_5 VDDPE_5 VNWC_6 VPW_5 VSSE WL[0] WL[1] sram464x144CCHD4
XMEM_L_COL_6 BL[0]_6 BL[1]_6 BL[2]_6 BL[3]_6 CORED00_496 CORED01_498
+  CORED10_500 CORED11_502 CORED20_504 CORED21_506 CORED30_508 CORED31_510
+  NBL[0]_6 NBL[1]_6 NBL[2]_6 NBL[3]_6 NCORED00_512 NCORED01_514 NCORED10_516
+  NCORED11_518 NCORED20_520 NCORED21_522 NCORED30_524 NCORED31_526 VDDC_6
+  VDDCE_6 VDDPE_6 VNWC_7 VPW_6 VSSE WL[0] WL[1] sram464x144CCHD4
XMEM_L_COL_7 BL[0]_7 BL[1]_7 BL[2]_7 BL[3]_7 CORED00_528 CORED01_530
+  CORED10_532 CORED11_534 CORED20_536 CORED21_538 CORED30_540 CORED31_542
+  NBL[0]_7 NBL[1]_7 NBL[2]_7 NBL[3]_7 NCORED00_544 NCORED01_546 NCORED10_548
+  NCORED11_550 NCORED20_552 NCORED21_554 NCORED30_556 NCORED31_558 VDDC_7
+  VDDCE_7 VDDPE_7 VNWC_8 VPW_7 VSSE WL[0] WL[1] sram464x144CCHD4
XMEM_L_COL_8 BL[0]_8 BL[1]_8 BL[2]_8 BL[3]_8 CORED00_560 CORED01_562
+  CORED10_564 CORED11_566 CORED20_568 CORED21_570 CORED30_572 CORED31_574
+  NBL[0]_8 NBL[1]_8 NBL[2]_8 NBL[3]_8 NCORED00_576 NCORED01_578 NCORED10_580
+  NCORED11_582 NCORED20_584 NCORED21_586 NCORED30_588 NCORED31_590 VDDC_8
+  VDDCE_8 VDDPE_8 VNWC_9 VPW_8 VSSE WL[0] WL[1] sram464x144CCHD4
XMEM_L_COL_9 BL[0]_9 BL[1]_9 BL[2]_9 BL[3]_9 CORED00_592 CORED01_594
+  CORED10_596 CORED11_598 CORED20_600 CORED21_602 CORED30_604 CORED31_606
+  NBL[0]_9 NBL[1]_9 NBL[2]_9 NBL[3]_9 NCORED00_608 NCORED01_610 NCORED10_612
+  NCORED11_614 NCORED20_616 NCORED21_618 NCORED30_620 NCORED31_622 VDDC_9
+  VDDCE_9 VDDPE_9 VNWC_10 VPW_9 VSSE WL[0] WL[1] sram464x144CCHD4
XMEM_L_COL_EDGEL VNWC_0 VNWP_0 VSSE VSSE WL[0] WL[1] sram464x144CCHD4_EDG
XMEM_L_COL_EDGER VNWC_37 VNWP_1 VSSE VSSE WL[0] WL[1] sram464x144CCHD4WD_EDG
.ENDS sram464x144MEM_L_MIDB_ROW
****
.SUBCKT sram464x144MEMCORE_L BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5
+  BL[0]_6 BL[0]_7 BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13
+  BL[0]_14 BL[0]_15 BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21
+  BL[0]_22 BL[0]_23 BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29
+  BL[0]_30 BL[0]_31 BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1
+  BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10
+  BL[1]_11 BL[1]_12 BL[1]_13 BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18
+  BL[1]_19 BL[1]_20 BL[1]_21 BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26
+  BL[1]_27 BL[1]_28 BL[1]_29 BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34
+  BL[1]_35 BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7
+  BL[2]_8 BL[2]_9 BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15
+  BL[2]_16 BL[2]_17 BL[2]_18 BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23
+  BL[2]_24 BL[2]_25 BL[2]_26 BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31
+  BL[2]_32 BL[2]_33 BL[2]_34 BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4
+  BL[3]_5 BL[3]_6 BL[3]_7 BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13
+  BL[3]_14 BL[3]_15 BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21
+  BL[3]_22 BL[3]_23 BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29
+  BL[3]_30 BL[3]_31 BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1
+  NBL[0]_2 NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9
+  NBL[0]_10 NBL[0]_11 NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16
+  NBL[0]_17 NBL[0]_18 NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23
+  NBL[0]_24 NBL[0]_25 NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30
+  NBL[0]_31 NBL[0]_32 NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1
+  NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9
+  NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16
+  NBL[1]_17 NBL[1]_18 NBL[1]_19 NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23
+  NBL[1]_24 NBL[1]_25 NBL[1]_26 NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30
+  NBL[1]_31 NBL[1]_32 NBL[1]_33 NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1
+  NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9
+  NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13 NBL[2]_14 NBL[2]_15 NBL[2]_16
+  NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20 NBL[2]_21 NBL[2]_22 NBL[2]_23
+  NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27 NBL[2]_28 NBL[2]_29 NBL[2]_30
+  NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34 NBL[2]_35 NBL[3]_0 NBL[3]_1
+  NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 NBL[3]_8 NBL[3]_9
+  NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13 NBL[3]_14 NBL[3]_15 NBL[3]_16
+  NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20 NBL[3]_21 NBL[3]_22 NBL[3]_23
+  NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27 NBL[3]_28 NBL[3]_29 NBL[3]_30
+  NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34 NBL[3]_35 VDDC VDDPE_0 VDDPE_1
+  VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8 VDDPE_9 VDDPE_10
+  VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16 VDDPE_17 VDDPE_18
+  VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24 VDDPE_25 VDDPE_26
+  VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32 VDDPE_33 VDDPE_34
+  VDDPE_35 VNWP_0 VNWP_1 VSSE WL[0]_0 WL[0]_1 WL[0]_2 WL[0]_3 WL[0]_4 WL[0]_5
+  WL[0]_6 WL[0]_7 WL[0]_8 WL[0]_9 WL[0]_10 WL[0]_11 WL[0]_12 WL[0]_13
+  WL[0]_14 WL[0]_15 WL[0]_16 WL[0]_17 WL[0]_18 WL[0]_19 WL[0]_20 WL[0]_21
+  WL[0]_22 WL[0]_23 WL[0]_24 WL[0]_25 WL[0]_26 WL[0]_27 WL[0]_28 WL[0]_29
+  WL[0]_30 WL[0]_31 WL[0]_32 WL[0]_33 WL[0]_34 WL[0]_35 WL[0]_36 WL[0]_37
+  WL[0]_38 WL[0]_39 WL[0]_40 WL[0]_41 WL[0]_42 WL[0]_43 WL[0]_44 WL[0]_45
+  WL[0]_46 WL[0]_47 WL[0]_48 WL[0]_49 WL[0]_50 WL[0]_51 WL[0]_52 WL[0]_53
+  WL[0]_54 WL[0]_55 WL[0]_56 WL[0]_57 WL[0]_58 WL[0]_59 WL[0]_60 WL[0]_61
+  WL[0]_62 WL[0]_63 WL[0]_64 WL[0]_65 WL[0]_66 WL[0]_67 WL[0]_68 WL[0]_69
+  WL[0]_70 WL[0]_71 WL[0]_72 WL[0]_73 WL[0]_74 WL[0]_75 WL[0]_76 WL[0]_77
+  WL[0]_78 WL[0]_79 WL[0]_80 WL[0]_81 WL[0]_82 WL[0]_83 WL[0]_84 WL[0]_85
+  WL[0]_86 WL[0]_87 WL[0]_88 WL[0]_89 WL[0]_90 WL[0]_91 WL[0]_92 WL[0]_93
+  WL[0]_94 WL[0]_95 WL[0]_96 WL[0]_97 WL[0]_98 WL[0]_99 WL[0]_100 WL[0]_101
+  WL[0]_102 WL[0]_103 WL[0]_104 WL[0]_105 WL[0]_106 WL[0]_107 WL[0]_108
+  WL[0]_109 WL[0]_110 WL[0]_111 WL[0]_112 WL[0]_113 WL[0]_114 WL[0]_115
+  WL[1]_0 WL[1]_1 WL[1]_2 WL[1]_3 WL[1]_4 WL[1]_5 WL[1]_6 WL[1]_7 WL[1]_8
+  WL[1]_9 WL[1]_10 WL[1]_11 WL[1]_12 WL[1]_13 WL[1]_14 WL[1]_15 WL[1]_16
+  WL[1]_17 WL[1]_18 WL[1]_19 WL[1]_20 WL[1]_21 WL[1]_22 WL[1]_23 WL[1]_24
+  WL[1]_25 WL[1]_26 WL[1]_27 WL[1]_28 WL[1]_29 WL[1]_30 WL[1]_31 WL[1]_32
+  WL[1]_33 WL[1]_34 WL[1]_35 WL[1]_36 WL[1]_37 WL[1]_38 WL[1]_39 WL[1]_40
+  WL[1]_41 WL[1]_42 WL[1]_43 WL[1]_44 WL[1]_45 WL[1]_46 WL[1]_47 WL[1]_48
+  WL[1]_49 WL[1]_50 WL[1]_51 WL[1]_52 WL[1]_53 WL[1]_54 WL[1]_55 WL[1]_56
+  WL[1]_57 WL[1]_58 WL[1]_59 WL[1]_60 WL[1]_61 WL[1]_62 WL[1]_63 WL[1]_64
+  WL[1]_65 WL[1]_66 WL[1]_67 WL[1]_68 WL[1]_69 WL[1]_70 WL[1]_71 WL[1]_72
+  WL[1]_73 WL[1]_74 WL[1]_75 WL[1]_76 WL[1]_77 WL[1]_78 WL[1]_79 WL[1]_80
+  WL[1]_81 WL[1]_82 WL[1]_83 WL[1]_84 WL[1]_85 WL[1]_86 WL[1]_87 WL[1]_88
+  WL[1]_89 WL[1]_90 WL[1]_91 WL[1]_92 WL[1]_93 WL[1]_94 WL[1]_95 WL[1]_96
+  WL[1]_97 WL[1]_98 WL[1]_99 WL[1]_100 WL[1]_101 WL[1]_102 WL[1]_103
+  WL[1]_104 WL[1]_105 WL[1]_106 WL[1]_107 WL[1]_108 WL[1]_109 WL[1]_110
+  WL[1]_111 WL[1]_112 WL[1]_113 WL[1]_114 WL[1]_115
** sram464x144MEMCORE_L: 202938 flat devices **
XMEM_L_ROW_1 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_1 WL[1]_1
+  sram464x144MEM_L_ROW
XMEM_L_ROW_10 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_10 WL[1]_10
+  sram464x144MEM_L_ROW
XMEM_L_ROW_100 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_100 WL[1]_100
+  sram464x144MEM_L_ROW
XMEM_L_ROW_101 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_101 WL[1]_101
+  sram464x144MEM_L_ROW
XMEM_L_ROW_102 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_102 WL[1]_102
+  sram464x144MEM_L_ROW
XMEM_L_ROW_103 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_103 WL[1]_103
+  sram464x144MEM_L_ROW
XMEM_L_ROW_104 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_104 WL[1]_104
+  sram464x144MEM_L_ROW
XMEM_L_ROW_105 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_105 WL[1]_105
+  sram464x144MEM_L_ROW
XMEM_L_ROW_106 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_106 WL[1]_106
+  sram464x144MEM_L_ROW
XMEM_L_ROW_107 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_107 WL[1]_107
+  sram464x144MEM_L_ROW
XMEM_L_ROW_108 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_108 WL[1]_108
+  sram464x144MEM_L_ROW
XMEM_L_ROW_109 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_109 WL[1]_109
+  sram464x144MEM_L_ROW
XMEM_L_ROW_11 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_11 WL[1]_11
+  sram464x144MEM_L_ROW
XMEM_L_ROW_110 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_110 WL[1]_110
+  sram464x144MEM_L_ROW
XMEM_L_ROW_111 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_111 WL[1]_111
+  sram464x144MEM_L_ROW
XMEM_L_ROW_112 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_112 WL[1]_112
+  sram464x144MEM_L_ROW
XMEM_L_ROW_113 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_113 WL[1]_113
+  sram464x144MEM_L_ROW
XMEM_L_ROW_114 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_114 WL[1]_114
+  sram464x144MEM_L_ROW
XMEM_L_ROW_12 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_12 WL[1]_12
+  sram464x144MEM_L_ROW
XMEM_L_ROW_13 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_13 WL[1]_13
+  sram464x144MEM_L_ROW
XMEM_L_ROW_14 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_14 WL[1]_14
+  sram464x144MEM_L_ROW
XMEM_L_ROW_15 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_15 WL[1]_15
+  sram464x144MEM_L_ROW
XMEM_L_ROW_16 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_16 WL[1]_16
+  sram464x144MEM_L_ROW
XMEM_L_ROW_17 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_17 WL[1]_17
+  sram464x144MEM_L_ROW
XMEM_L_ROW_18 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_18 WL[1]_18
+  sram464x144MEM_L_ROW
XMEM_L_ROW_19 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_19 WL[1]_19
+  sram464x144MEM_L_ROW
XMEM_L_ROW_2 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_2 WL[1]_2
+  sram464x144MEM_L_ROW
XMEM_L_ROW_20 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_20 WL[1]_20
+  sram464x144MEM_L_ROW
XMEM_L_ROW_21 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_21 WL[1]_21
+  sram464x144MEM_L_ROW
XMEM_L_ROW_22 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_22 WL[1]_22
+  sram464x144MEM_L_ROW
XMEM_L_ROW_23 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_23 WL[1]_23
+  sram464x144MEM_L_ROW
XMEM_L_ROW_24 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_24 WL[1]_24
+  sram464x144MEM_L_ROW
XMEM_L_ROW_25 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_25 WL[1]_25
+  sram464x144MEM_L_ROW
XMEM_L_ROW_26 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_26 WL[1]_26
+  sram464x144MEM_L_ROW
XMEM_L_ROW_27 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_27 WL[1]_27
+  sram464x144MEM_L_ROW
XMEM_L_ROW_28 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_28 WL[1]_28
+  sram464x144MEM_L_ROW
XMEM_L_ROW_29 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_29 WL[1]_29
+  sram464x144MEM_L_ROW
XMEM_L_ROW_3 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_3 WL[1]_3
+  sram464x144MEM_L_ROW
XMEM_L_ROW_30 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_30 WL[1]_30
+  sram464x144MEM_L_ROW
XMEM_L_ROW_31 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_31 WL[1]_31
+  sram464x144MEM_L_ROW
XMEM_L_ROW_32 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_32 WL[1]_32
+  sram464x144MEM_L_ROW
XMEM_L_ROW_33 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_33 WL[1]_33
+  sram464x144MEM_L_ROW
XMEM_L_ROW_34 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_34 WL[1]_34
+  sram464x144MEM_L_ROW
XMEM_L_ROW_35 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_35 WL[1]_35
+  sram464x144MEM_L_ROW
XMEM_L_ROW_36 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_36 WL[1]_36
+  sram464x144MEM_L_ROW
XMEM_L_ROW_37 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_37 WL[1]_37
+  sram464x144MEM_L_ROW
XMEM_L_ROW_38 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_38 WL[1]_38
+  sram464x144MEM_L_ROW
XMEM_L_ROW_39 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_39 WL[1]_39
+  sram464x144MEM_L_ROW
XMEM_L_ROW_4 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_4 WL[1]_4
+  sram464x144MEM_L_ROW
XMEM_L_ROW_40 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_40 WL[1]_40
+  sram464x144MEM_L_ROW
XMEM_L_ROW_41 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_41 WL[1]_41
+  sram464x144MEM_L_ROW
XMEM_L_ROW_42 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_42 WL[1]_42
+  sram464x144MEM_L_ROW
XMEM_L_ROW_43 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_43 WL[1]_43
+  sram464x144MEM_L_ROW
XMEM_L_ROW_44 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_44 WL[1]_44
+  sram464x144MEM_L_ROW
XMEM_L_ROW_45 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_45 WL[1]_45
+  sram464x144MEM_L_ROW
XMEM_L_ROW_46 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_46 WL[1]_46
+  sram464x144MEM_L_ROW
XMEM_L_ROW_47 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_47 WL[1]_47
+  sram464x144MEM_L_ROW
XMEM_L_ROW_48 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_48 WL[1]_48
+  sram464x144MEM_L_ROW
XMEM_L_ROW_49 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_49 WL[1]_49
+  sram464x144MEM_L_ROW
XMEM_L_ROW_5 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_5 WL[1]_5
+  sram464x144MEM_L_ROW
XMEM_L_ROW_50 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_50 WL[1]_50
+  sram464x144MEM_L_ROW
XMEM_L_ROW_51 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_51 WL[1]_51
+  sram464x144MEM_L_ROW
XMEM_L_ROW_52 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_52 WL[1]_52
+  sram464x144MEM_L_ROW
XMEM_L_ROW_53 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_53 WL[1]_53
+  sram464x144MEM_L_ROW
XMEM_L_ROW_54 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_54 WL[1]_54
+  sram464x144MEM_L_ROW
XMEM_L_ROW_55 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_55 WL[1]_55
+  sram464x144MEM_L_ROW
XMEM_L_ROW_59 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_59 WL[1]_59
+  sram464x144MEM_L_ROW
XMEM_L_ROW_6 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_6 WL[1]_6
+  sram464x144MEM_L_ROW
XMEM_L_ROW_60 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_60 WL[1]_60
+  sram464x144MEM_L_ROW
XMEM_L_ROW_61 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_61 WL[1]_61
+  sram464x144MEM_L_ROW
XMEM_L_ROW_62 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_62 WL[1]_62
+  sram464x144MEM_L_ROW
XMEM_L_ROW_63 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_63 WL[1]_63
+  sram464x144MEM_L_ROW
XMEM_L_ROW_64 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_64 WL[1]_64
+  sram464x144MEM_L_ROW
XMEM_L_ROW_65 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_65 WL[1]_65
+  sram464x144MEM_L_ROW
XMEM_L_ROW_66 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_66 WL[1]_66
+  sram464x144MEM_L_ROW
XMEM_L_ROW_67 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_67 WL[1]_67
+  sram464x144MEM_L_ROW
XMEM_L_ROW_68 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_68 WL[1]_68
+  sram464x144MEM_L_ROW
XMEM_L_ROW_69 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_69 WL[1]_69
+  sram464x144MEM_L_ROW
XMEM_L_ROW_7 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_7 WL[1]_7
+  sram464x144MEM_L_ROW
XMEM_L_ROW_70 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_70 WL[1]_70
+  sram464x144MEM_L_ROW
XMEM_L_ROW_71 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_71 WL[1]_71
+  sram464x144MEM_L_ROW
XMEM_L_ROW_72 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_72 WL[1]_72
+  sram464x144MEM_L_ROW
XMEM_L_ROW_73 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_73 WL[1]_73
+  sram464x144MEM_L_ROW
XMEM_L_ROW_74 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_74 WL[1]_74
+  sram464x144MEM_L_ROW
XMEM_L_ROW_75 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_75 WL[1]_75
+  sram464x144MEM_L_ROW
XMEM_L_ROW_76 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_76 WL[1]_76
+  sram464x144MEM_L_ROW
XMEM_L_ROW_77 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_77 WL[1]_77
+  sram464x144MEM_L_ROW
XMEM_L_ROW_78 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_78 WL[1]_78
+  sram464x144MEM_L_ROW
XMEM_L_ROW_79 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_79 WL[1]_79
+  sram464x144MEM_L_ROW
XMEM_L_ROW_8 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_8 WL[1]_8
+  sram464x144MEM_L_ROW
XMEM_L_ROW_80 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_80 WL[1]_80
+  sram464x144MEM_L_ROW
XMEM_L_ROW_81 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_81 WL[1]_81
+  sram464x144MEM_L_ROW
XMEM_L_ROW_82 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_82 WL[1]_82
+  sram464x144MEM_L_ROW
XMEM_L_ROW_83 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_83 WL[1]_83
+  sram464x144MEM_L_ROW
XMEM_L_ROW_84 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_84 WL[1]_84
+  sram464x144MEM_L_ROW
XMEM_L_ROW_85 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_85 WL[1]_85
+  sram464x144MEM_L_ROW
XMEM_L_ROW_86 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_86 WL[1]_86
+  sram464x144MEM_L_ROW
XMEM_L_ROW_87 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_87 WL[1]_87
+  sram464x144MEM_L_ROW
XMEM_L_ROW_88 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_88 WL[1]_88
+  sram464x144MEM_L_ROW
XMEM_L_ROW_89 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_89 WL[1]_89
+  sram464x144MEM_L_ROW
XMEM_L_ROW_9 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_9 WL[1]_9
+  sram464x144MEM_L_ROW
XMEM_L_ROW_90 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_90 WL[1]_90
+  sram464x144MEM_L_ROW
XMEM_L_ROW_91 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_91 WL[1]_91
+  sram464x144MEM_L_ROW
XMEM_L_ROW_92 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_92 WL[1]_92
+  sram464x144MEM_L_ROW
XMEM_L_ROW_93 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_93 WL[1]_93
+  sram464x144MEM_L_ROW
XMEM_L_ROW_94 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_94 WL[1]_94
+  sram464x144MEM_L_ROW
XMEM_L_ROW_95 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_95 WL[1]_95
+  sram464x144MEM_L_ROW
XMEM_L_ROW_96 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_96 WL[1]_96
+  sram464x144MEM_L_ROW
XMEM_L_ROW_97 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_97 WL[1]_97
+  sram464x144MEM_L_ROW
XMEM_L_ROW_98 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_98 WL[1]_98
+  sram464x144MEM_L_ROW
XMEM_L_ROW_99 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_99 WL[1]_99
+  sram464x144MEM_L_ROW
XMEM_L_ROW_BOT BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_0 WL[1]_0
+  sram464x144MEM_L_BOT_ROW
XMEM_L_ROW_CAP BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6
+  VDDPE_7 VDDPE_8 VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14
+  VDDPE_15 VDDPE_16 VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22
+  VDDPE_23 VDDPE_24 VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30
+  VDDPE_31 VDDPE_32 VDDPE_33 VDDPE_34 VDDPE_35 VNWP_0 VNWP_1 VSSE
+  sram464x144MEM_SLICE_CAP_L
XMEM_L_ROW_MID BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_57 WL[1]_57
+  sram464x144MEM_L_MID_ROW
XMEM_L_ROW_MIDB BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6
+  BL[0]_7 BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14
+  BL[0]_15 BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22
+  BL[0]_23 BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30
+  BL[0]_31 BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2
+  BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11
+  BL[1]_12 BL[1]_13 BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19
+  BL[1]_20 BL[1]_21 BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27
+  BL[1]_28 BL[1]_29 BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35
+  BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8
+  BL[2]_9 BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16
+  BL[2]_17 BL[2]_18 BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24
+  BL[2]_25 BL[2]_26 BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32
+  BL[2]_33 BL[2]_34 BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5
+  BL[3]_6 BL[3]_7 BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13
+  BL[3]_14 BL[3]_15 BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21
+  BL[3]_22 BL[3]_23 BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29
+  BL[3]_30 BL[3]_31 BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1
+  NBL[0]_2 NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9
+  NBL[0]_10 NBL[0]_11 NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16
+  NBL[0]_17 NBL[0]_18 NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23
+  NBL[0]_24 NBL[0]_25 NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30
+  NBL[0]_31 NBL[0]_32 NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1
+  NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9
+  NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16
+  NBL[1]_17 NBL[1]_18 NBL[1]_19 NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23
+  NBL[1]_24 NBL[1]_25 NBL[1]_26 NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30
+  NBL[1]_31 NBL[1]_32 NBL[1]_33 NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1
+  NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9
+  NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13 NBL[2]_14 NBL[2]_15 NBL[2]_16
+  NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20 NBL[2]_21 NBL[2]_22 NBL[2]_23
+  NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27 NBL[2]_28 NBL[2]_29 NBL[2]_30
+  NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34 NBL[2]_35 NBL[3]_0 NBL[3]_1
+  NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 NBL[3]_8 NBL[3]_9
+  NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13 NBL[3]_14 NBL[3]_15 NBL[3]_16
+  NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20 NBL[3]_21 NBL[3]_22 NBL[3]_23
+  NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27 NBL[3]_28 NBL[3]_29 NBL[3]_30
+  NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34 NBL[3]_35 VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4
+  VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8 VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13
+  VDDPE_14 VDDPE_15 VDDPE_16 VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21
+  VDDPE_22 VDDPE_23 VDDPE_24 VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29
+  VDDPE_30 VDDPE_31 VDDPE_32 VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  WL[0]_56 WL[1]_56 sram464x144MEM_L_MIDB_ROW
XMEM_L_ROW_MIDT BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6
+  BL[0]_7 BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14
+  BL[0]_15 BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22
+  BL[0]_23 BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30
+  BL[0]_31 BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2
+  BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11
+  BL[1]_12 BL[1]_13 BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19
+  BL[1]_20 BL[1]_21 BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27
+  BL[1]_28 BL[1]_29 BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35
+  BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8
+  BL[2]_9 BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16
+  BL[2]_17 BL[2]_18 BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24
+  BL[2]_25 BL[2]_26 BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32
+  BL[2]_33 BL[2]_34 BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5
+  BL[3]_6 BL[3]_7 BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13
+  BL[3]_14 BL[3]_15 BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21
+  BL[3]_22 BL[3]_23 BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29
+  BL[3]_30 BL[3]_31 BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1
+  NBL[0]_2 NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9
+  NBL[0]_10 NBL[0]_11 NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16
+  NBL[0]_17 NBL[0]_18 NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23
+  NBL[0]_24 NBL[0]_25 NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30
+  NBL[0]_31 NBL[0]_32 NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1
+  NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9
+  NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16
+  NBL[1]_17 NBL[1]_18 NBL[1]_19 NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23
+  NBL[1]_24 NBL[1]_25 NBL[1]_26 NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30
+  NBL[1]_31 NBL[1]_32 NBL[1]_33 NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1
+  NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9
+  NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13 NBL[2]_14 NBL[2]_15 NBL[2]_16
+  NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20 NBL[2]_21 NBL[2]_22 NBL[2]_23
+  NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27 NBL[2]_28 NBL[2]_29 NBL[2]_30
+  NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34 NBL[2]_35 NBL[3]_0 NBL[3]_1
+  NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 NBL[3]_8 NBL[3]_9
+  NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13 NBL[3]_14 NBL[3]_15 NBL[3]_16
+  NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20 NBL[3]_21 NBL[3]_22 NBL[3]_23
+  NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27 NBL[3]_28 NBL[3]_29 NBL[3]_30
+  NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34 NBL[3]_35 VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4
+  VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8 VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13
+  VDDPE_14 VDDPE_15 VDDPE_16 VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21
+  VDDPE_22 VDDPE_23 VDDPE_24 VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29
+  VDDPE_30 VDDPE_31 VDDPE_32 VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  WL[0]_58 WL[1]_58 sram464x144MEM_L_MIDT_ROW
XMEM_L_ROW_TOP BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE WL[0]_115 WL[1]_115
+  sram464x144MEM_L_TOP_ROW
XMEM_L_STRAP0 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3
+  VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8 VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12
+  VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16 VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20
+  VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24 VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28
+  VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32 VDDPE_33 VDDPE_34 VDDPE_35 VDDC VNWP_0
+  VNWP_1 VSSE sram464x144MEM_L_STRAPROW
.ENDS sram464x144MEMCORE_L
****
.SUBCKT sram464x144MEM_R_MIDB_ROW BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4
+  BL[0]_5 BL[0]_6 BL[0]_7 BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13
+  BL[0]_14 BL[0]_15 BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21
+  BL[0]_22 BL[0]_23 BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29
+  BL[0]_30 BL[0]_31 BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1
+  BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10
+  BL[1]_11 BL[1]_12 BL[1]_13 BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18
+  BL[1]_19 BL[1]_20 BL[1]_21 BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26
+  BL[1]_27 BL[1]_28 BL[1]_29 BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34
+  BL[1]_35 BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7
+  BL[2]_8 BL[2]_9 BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15
+  BL[2]_16 BL[2]_17 BL[2]_18 BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23
+  BL[2]_24 BL[2]_25 BL[2]_26 BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31
+  BL[2]_32 BL[2]_33 BL[2]_34 BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4
+  BL[3]_5 BL[3]_6 BL[3]_7 BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13
+  BL[3]_14 BL[3]_15 BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21
+  BL[3]_22 BL[3]_23 BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29
+  BL[3]_30 BL[3]_31 BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1
+  NBL[0]_2 NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9
+  NBL[0]_10 NBL[0]_11 NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16
+  NBL[0]_17 NBL[0]_18 NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23
+  NBL[0]_24 NBL[0]_25 NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30
+  NBL[0]_31 NBL[0]_32 NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1
+  NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9
+  NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16
+  NBL[1]_17 NBL[1]_18 NBL[1]_19 NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23
+  NBL[1]_24 NBL[1]_25 NBL[1]_26 NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30
+  NBL[1]_31 NBL[1]_32 NBL[1]_33 NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1
+  NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9
+  NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13 NBL[2]_14 NBL[2]_15 NBL[2]_16
+  NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20 NBL[2]_21 NBL[2]_22 NBL[2]_23
+  NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27 NBL[2]_28 NBL[2]_29 NBL[2]_30
+  NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34 NBL[2]_35 NBL[3]_0 NBL[3]_1
+  NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 NBL[3]_8 NBL[3]_9
+  NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13 NBL[3]_14 NBL[3]_15 NBL[3]_16
+  NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20 NBL[3]_21 NBL[3]_22 NBL[3]_23
+  NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27 NBL[3]_28 NBL[3]_29 NBL[3]_30
+  NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34 NBL[3]_35 VDDCE_0 VDDCE_1 VDDCE_2
+  VDDCE_3 VDDCE_4 VDDCE_5 VDDCE_6 VDDCE_7 VDDCE_8 VDDCE_9 VDDCE_10 VDDCE_11
+  VDDCE_12 VDDCE_13 VDDCE_14 VDDCE_15 VDDCE_16 VDDCE_17 VDDCE_18 VDDCE_19
+  VDDCE_20 VDDCE_21 VDDCE_22 VDDCE_23 VDDCE_24 VDDCE_25 VDDCE_26 VDDCE_27
+  VDDCE_28 VDDCE_29 VDDCE_30 VDDCE_31 VDDCE_32 VDDCE_33 VDDCE_34 VDDCE_35
+  VDDC_0 VDDC_1 VDDC_2 VDDC_3 VDDC_4 VDDC_5 VDDC_6 VDDC_7 VDDC_8 VDDC_9
+  VDDC_10 VDDC_11 VDDC_12 VDDC_13 VDDC_14 VDDC_15 VDDC_16 VDDC_17 VDDC_18
+  VDDC_19 VDDC_20 VDDC_21 VDDC_22 VDDC_23 VDDC_24 VDDC_25 VDDC_26 VDDC_27
+  VDDC_28 VDDC_29 VDDC_30 VDDC_31 VDDC_32 VDDC_33 VDDC_34 VDDC_35 VDDPE_0
+  VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8 VDDPE_9
+  VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16 VDDPE_17
+  VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24 VDDPE_25
+  VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32 VDDPE_33
+  VDDPE_34 VDDPE_35 VNWC_0 VNWC_1 VNWC_2 VNWC_3 VNWC_4 VNWC_5 VNWC_6 VNWC_7
+  VNWC_8 VNWC_9 VNWC_10 VNWC_11 VNWC_12 VNWC_13 VNWC_14 VNWC_15 VNWC_16
+  VNWC_17 VNWC_18 VNWC_19 VNWC_20 VNWC_21 VNWC_22 VNWC_23 VNWC_24 VNWC_25
+  VNWC_26 VNWC_27 VNWC_28 VNWC_29 VNWC_30 VNWC_31 VNWC_32 VNWC_33 VNWC_34
+  VNWC_35 VNWC_36 VNWC_37 VNWP_0 VNWP_1 VPW_0 VPW_1 VPW_2 VPW_3 VPW_4 VPW_5
+  VPW_6 VPW_7 VPW_8 VPW_9 VPW_10 VPW_11 VPW_12 VPW_13 VPW_14 VPW_15 VPW_16
+  VPW_17 VPW_18 VPW_19 VPW_20 VPW_21 VPW_22 VPW_23 VPW_24 VPW_25 VPW_26
+  VPW_27 VPW_28 VPW_29 VPW_30 VPW_31 VPW_32 VPW_33 VPW_34 VPW_35 VPW_36 WL[0]
+  WL[1]
** sram464x144MEM_R_MIDB_ROW: 1732 flat devices **
XMEM_R_COL_0 BL[0]_0 BL[1]_0 BL[2]_0 BL[3]_0 CORED00_304 CORED01_306
+  CORED10_308 CORED11_310 CORED20_312 CORED21_314 CORED30_316 CORED31_318
+  NBL[0]_0 NBL[1]_0 NBL[2]_0 NBL[3]_0 NCORED00_320 NCORED01_322 NCORED10_324
+  NCORED11_326 NCORED20_328 NCORED21_330 NCORED30_332 NCORED31_334 VDDC_0
+  VDDCE_0 VDDPE_0 VNWC_1 VPW_1 VPW_0 WL[0] WL[1] sram464x144CCHD4
XMEM_R_COL_1 BL[0]_1 BL[1]_1 BL[2]_1 BL[3]_1 CORED00_336 CORED01_338
+  CORED10_340 CORED11_342 CORED20_344 CORED21_346 CORED30_348 CORED31_350
+  NBL[0]_1 NBL[1]_1 NBL[2]_1 NBL[3]_1 NCORED00_352 NCORED01_354 NCORED10_356
+  NCORED11_358 NCORED20_360 NCORED21_362 NCORED30_364 NCORED31_366 VDDC_1
+  VDDCE_1 VDDPE_1 VNWC_2 VPW_2 VPW_0 WL[0] WL[1] sram464x144CCHD4
XMEM_R_COL_10 BL[0]_10 BL[1]_10 BL[2]_10 BL[3]_10 CORED00_624 CORED01_626
+  CORED10_628 CORED11_630 CORED20_632 CORED21_634 CORED30_636 CORED31_638
+  NBL[0]_10 NBL[1]_10 NBL[2]_10 NBL[3]_10 NCORED00_640 NCORED01_642
+  NCORED10_644 NCORED11_646 NCORED20_648 NCORED21_650 NCORED30_652
+  NCORED31_654 VDDC_10 VDDCE_10 VDDPE_10 VNWC_11 VPW_11 VPW_0 WL[0] WL[1]
+  sram464x144CCHD4
XMEM_R_COL_11 BL[0]_11 BL[1]_11 BL[2]_11 BL[3]_11 CORED00_656 CORED01_658
+  CORED10_660 CORED11_662 CORED20_664 CORED21_666 CORED30_668 CORED31_670
+  NBL[0]_11 NBL[1]_11 NBL[2]_11 NBL[3]_11 NCORED00_672 NCORED01_674
+  NCORED10_676 NCORED11_678 NCORED20_680 NCORED21_682 NCORED30_684
+  NCORED31_686 VDDC_11 VDDCE_11 VDDPE_11 VNWC_12 VPW_12 VPW_0 WL[0] WL[1]
+  sram464x144CCHD4
XMEM_R_COL_12 BL[0]_12 BL[1]_12 BL[2]_12 BL[3]_12 CORED00_688 CORED01_690
+  CORED10_692 CORED11_694 CORED20_696 CORED21_698 CORED30_700 CORED31_702
+  NBL[0]_12 NBL[1]_12 NBL[2]_12 NBL[3]_12 NCORED00_704 NCORED01_706
+  NCORED10_708 NCORED11_710 NCORED20_712 NCORED21_714 NCORED30_716
+  NCORED31_718 VDDC_12 VDDCE_12 VDDPE_12 VNWC_13 VPW_13 VPW_0 WL[0] WL[1]
+  sram464x144CCHD4
XMEM_R_COL_13 BL[0]_13 BL[1]_13 BL[2]_13 BL[3]_13 CORED00_784 CORED01_786
+  CORED10_788 CORED11_790 CORED20_792 CORED21_794 CORED30_796 CORED31_798
+  NBL[0]_13 NBL[1]_13 NBL[2]_13 NBL[3]_13 NCORED00_800 NCORED01_802
+  NCORED10_804 NCORED11_806 NCORED20_808 NCORED21_810 NCORED30_812
+  NCORED31_814 VDDC_13 VDDCE_13 VDDPE_13 VNWC_14 VPW_14 VPW_0 WL[0] WL[1]
+  sram464x144CCHD4
XMEM_R_COL_14 BL[0]_14 BL[1]_14 BL[2]_14 BL[3]_14 CORED00_848 CORED01_850
+  CORED10_852 CORED11_854 CORED20_856 CORED21_858 CORED30_860 CORED31_862
+  NBL[0]_14 NBL[1]_14 NBL[2]_14 NBL[3]_14 NCORED00_864 NCORED01_866
+  NCORED10_868 NCORED11_870 NCORED20_872 NCORED21_874 NCORED30_876
+  NCORED31_878 VDDC_14 VDDCE_14 VDDPE_14 VNWC_15 VPW_15 VPW_0 WL[0] WL[1]
+  sram464x144CCHD4
XMEM_R_COL_15 BL[0]_15 BL[1]_15 BL[2]_15 BL[3]_15 CORED00_912 CORED01_914
+  CORED10_916 CORED11_918 CORED20_920 CORED21_922 CORED30_924 CORED31_926
+  NBL[0]_15 NBL[1]_15 NBL[2]_15 NBL[3]_15 NCORED00_928 NCORED01_930
+  NCORED10_932 NCORED11_934 NCORED20_936 NCORED21_938 NCORED30_940
+  NCORED31_942 VDDC_15 VDDCE_15 VDDPE_15 VNWC_16 VPW_16 VPW_0 WL[0] WL[1]
+  sram464x144CCHD4
XMEM_R_COL_16 BL[0]_16 BL[1]_16 BL[2]_16 BL[3]_16 CORED00_976 CORED01_978
+  CORED10_980 CORED11_982 CORED20_984 CORED21_986 CORED30_988 CORED31_990
+  NBL[0]_16 NBL[1]_16 NBL[2]_16 NBL[3]_16 NCORED00_992 NCORED01_994
+  NCORED10_996 NCORED11_998 NCORED20_1000 NCORED21_1002 NCORED30_1004
+  NCORED31_1006 VDDC_16 VDDCE_16 VDDPE_16 VNWC_17 VPW_17 VPW_0 WL[0] WL[1]
+  sram464x144CCHD4
XMEM_R_COL_17 BL[0]_17 BL[1]_17 BL[2]_17 BL[3]_17 CORED00_1040 CORED01_1042
+  CORED10_1044 CORED11_1046 CORED20_1048 CORED21_1050 CORED30_1052
+  CORED31_1054 NBL[0]_17 NBL[1]_17 NBL[2]_17 NBL[3]_17 NCORED00_1056
+  NCORED01_1058 NCORED10_1060 NCORED11_1062 NCORED20_1064 NCORED21_1066
+  NCORED30_1068 NCORED31_1070 VDDC_17 VDDCE_17 VDDPE_17 VNWC_18 VPW_18 VPW_0
+  WL[0] WL[1] sram464x144CCHD4
XMEM_R_COL_18 BL[0]_18 BL[1]_18 BL[2]_18 BL[3]_18 CORED00_1072 CORED01_1074
+  CORED10_1076 CORED11_1078 CORED20_1080 CORED21_1082 CORED30_1084
+  CORED31_1086 NBL[0]_18 NBL[1]_18 NBL[2]_18 NBL[3]_18 NCORED00_1088
+  NCORED01_1090 NCORED10_1092 NCORED11_1094 NCORED20_1096 NCORED21_1098
+  NCORED30_1100 NCORED31_1102 VDDC_18 VDDCE_18 VDDPE_18 VNWC_19 VPW_19 VPW_0
+  WL[0] WL[1] sram464x144CCHD4
XMEM_R_COL_19 BL[0]_19 BL[1]_19 BL[2]_19 BL[3]_19 CORED00_1104 CORED01_1106
+  CORED10_1108 CORED11_1110 CORED20_1112 CORED21_1114 CORED30_1116
+  CORED31_1118 NBL[0]_19 NBL[1]_19 NBL[2]_19 NBL[3]_19 NCORED00_1120
+  NCORED01_1122 NCORED10_1124 NCORED11_1126 NCORED20_1128 NCORED21_1130
+  NCORED30_1132 NCORED31_1134 VDDC_19 VDDCE_19 VDDPE_19 VNWC_20 VPW_20 VPW_0
+  WL[0] WL[1] sram464x144CCHD4
XMEM_R_COL_2 BL[0]_2 BL[1]_2 BL[2]_2 BL[3]_2 CORED00_368 CORED01_370
+  CORED10_372 CORED11_374 CORED20_376 CORED21_378 CORED30_380 CORED31_382
+  NBL[0]_2 NBL[1]_2 NBL[2]_2 NBL[3]_2 NCORED00_384 NCORED01_386 NCORED10_388
+  NCORED11_390 NCORED20_392 NCORED21_394 NCORED30_396 NCORED31_398 VDDC_2
+  VDDCE_2 VDDPE_2 VNWC_3 VPW_3 VPW_0 WL[0] WL[1] sram464x144CCHD4
XMEM_R_COL_20 BL[0]_20 BL[1]_20 BL[2]_20 BL[3]_20 CORED00 CORED01 CORED10
+  CORED11 CORED20 CORED21 CORED30 CORED31 NBL[0]_20 NBL[1]_20 NBL[2]_20
+  NBL[3]_20 NCORED00 NCORED01 NCORED10 NCORED11 NCORED20 NCORED21 NCORED30
+  NCORED31 VDDC_20 VDDCE_20 VDDPE_20 VNWC_21 VPW_21 VPW_0 WL[0] WL[1]
+  sram464x144CCHD4
XMEM_R_COL_21 BL[0]_21 BL[1]_21 BL[2]_21 BL[3]_21 CORED00_16 CORED01_18
+  CORED10_20 CORED11_22 CORED20_24 CORED21_26 CORED30_28 CORED31_30 NBL[0]_21
+  NBL[1]_21 NBL[2]_21 NBL[3]_21 NCORED00_32 NCORED01_34 NCORED10_36
+  NCORED11_38 NCORED20_40 NCORED21_42 NCORED30_44 NCORED31_46 VDDC_21
+  VDDCE_21 VDDPE_21 VNWC_22 VPW_22 VPW_0 WL[0] WL[1] sram464x144CCHD4
XMEM_R_COL_22 BL[0]_22 BL[1]_22 BL[2]_22 BL[3]_22 CORED00_48 CORED01_50
+  CORED10_52 CORED11_54 CORED20_56 CORED21_58 CORED30_60 CORED31_62 NBL[0]_22
+  NBL[1]_22 NBL[2]_22 NBL[3]_22 NCORED00_64 NCORED01_66 NCORED10_68
+  NCORED11_70 NCORED20_72 NCORED21_74 NCORED30_76 NCORED31_78 VDDC_22
+  VDDCE_22 VDDPE_22 VNWC_23 VPW_23 VPW_0 WL[0] WL[1] sram464x144CCHD4
XMEM_R_COL_23 BL[0]_23 BL[1]_23 BL[2]_23 BL[3]_23 CORED00_80 CORED01_82
+  CORED10_84 CORED11_86 CORED20_88 CORED21_90 CORED30_92 CORED31_94 NBL[0]_23
+  NBL[1]_23 NBL[2]_23 NBL[3]_23 NCORED00_96 NCORED01_98 NCORED10_100
+  NCORED11_102 NCORED20_104 NCORED21_106 NCORED30_108 NCORED31_110 VDDC_23
+  VDDCE_23 VDDPE_23 VNWC_24 VPW_24 VPW_0 WL[0] WL[1] sram464x144CCHD4
XMEM_R_COL_24 BL[0]_24 BL[1]_24 BL[2]_24 BL[3]_24 CORED00_112 CORED01_114
+  CORED10_116 CORED11_118 CORED20_120 CORED21_122 CORED30_124 CORED31_126
+  NBL[0]_24 NBL[1]_24 NBL[2]_24 NBL[3]_24 NCORED00_128 NCORED01_130
+  NCORED10_132 NCORED11_134 NCORED20_136 NCORED21_138 NCORED30_140
+  NCORED31_142 VDDC_24 VDDCE_24 VDDPE_24 VNWC_25 VPW_25 VPW_0 WL[0] WL[1]
+  sram464x144CCHD4
XMEM_R_COL_25 BL[0]_25 BL[1]_25 BL[2]_25 BL[3]_25 CORED00_144 CORED01_146
+  CORED10_148 CORED11_150 CORED20_152 CORED21_154 CORED30_156 CORED31_158
+  NBL[0]_25 NBL[1]_25 NBL[2]_25 NBL[3]_25 NCORED00_160 NCORED01_162
+  NCORED10_164 NCORED11_166 NCORED20_168 NCORED21_170 NCORED30_172
+  NCORED31_174 VDDC_25 VDDCE_25 VDDPE_25 VNWC_26 VPW_26 VPW_0 WL[0] WL[1]
+  sram464x144CCHD4
XMEM_R_COL_26 BL[0]_26 BL[1]_26 BL[2]_26 BL[3]_26 CORED00_176 CORED01_178
+  CORED10_180 CORED11_182 CORED20_184 CORED21_186 CORED30_188 CORED31_190
+  NBL[0]_26 NBL[1]_26 NBL[2]_26 NBL[3]_26 NCORED00_192 NCORED01_194
+  NCORED10_196 NCORED11_198 NCORED20_200 NCORED21_202 NCORED30_204
+  NCORED31_206 VDDC_26 VDDCE_26 VDDPE_26 VNWC_27 VPW_27 VPW_0 WL[0] WL[1]
+  sram464x144CCHD4
XMEM_R_COL_27 BL[0]_27 BL[1]_27 BL[2]_27 BL[3]_27 CORED00_208 CORED01_210
+  CORED10_212 CORED11_214 CORED20_216 CORED21_218 CORED30_220 CORED31_222
+  NBL[0]_27 NBL[1]_27 NBL[2]_27 NBL[3]_27 NCORED00_224 NCORED01_226
+  NCORED10_228 NCORED11_230 NCORED20_232 NCORED21_234 NCORED30_236
+  NCORED31_238 VDDC_27 VDDCE_27 VDDPE_27 VNWC_28 VPW_28 VPW_0 WL[0] WL[1]
+  sram464x144CCHD4
XMEM_R_COL_28 BL[0]_28 BL[1]_28 BL[2]_28 BL[3]_28 CORED00_240 CORED01_242
+  CORED10_244 CORED11_246 CORED20_248 CORED21_250 CORED30_252 CORED31_254
+  NBL[0]_28 NBL[1]_28 NBL[2]_28 NBL[3]_28 NCORED00_256 NCORED01_258
+  NCORED10_260 NCORED11_262 NCORED20_264 NCORED21_266 NCORED30_268
+  NCORED31_270 VDDC_28 VDDCE_28 VDDPE_28 VNWC_29 VPW_29 VPW_0 WL[0] WL[1]
+  sram464x144CCHD4
XMEM_R_COL_29 BL[0]_29 BL[1]_29 BL[2]_29 BL[3]_29 CORED00_272 CORED01_274
+  CORED10_276 CORED11_278 CORED20_280 CORED21_282 CORED30_284 CORED31_286
+  NBL[0]_29 NBL[1]_29 NBL[2]_29 NBL[3]_29 NCORED00_288 NCORED01_290
+  NCORED10_292 NCORED11_294 NCORED20_296 NCORED21_298 NCORED30_300
+  NCORED31_302 VDDC_29 VDDCE_29 VDDPE_29 VNWC_30 VPW_30 VPW_0 WL[0] WL[1]
+  sram464x144CCHD4
XMEM_R_COL_3 BL[0]_3 BL[1]_3 BL[2]_3 BL[3]_3 CORED00_400 CORED01_402
+  CORED10_404 CORED11_406 CORED20_408 CORED21_410 CORED30_412 CORED31_414
+  NBL[0]_3 NBL[1]_3 NBL[2]_3 NBL[3]_3 NCORED00_416 NCORED01_418 NCORED10_420
+  NCORED11_422 NCORED20_424 NCORED21_426 NCORED30_428 NCORED31_430 VDDC_3
+  VDDCE_3 VDDPE_3 VNWC_4 VPW_4 VPW_0 WL[0] WL[1] sram464x144CCHD4
XMEM_R_COL_30 BL[0]_30 BL[1]_30 BL[2]_30 BL[3]_30 CORED00_720 CORED01_722
+  CORED10_724 CORED11_726 CORED20_728 CORED21_730 CORED30_732 CORED31_734
+  NBL[0]_30 NBL[1]_30 NBL[2]_30 NBL[3]_30 NCORED00_736 NCORED01_738
+  NCORED10_740 NCORED11_742 NCORED20_744 NCORED21_746 NCORED30_748
+  NCORED31_750 VDDC_30 VDDCE_30 VDDPE_30 VNWC_31 VPW_31 VPW_0 WL[0] WL[1]
+  sram464x144CCHD4
XMEM_R_COL_31 BL[0]_31 BL[1]_31 BL[2]_31 BL[3]_31 CORED00_752 CORED01_754
+  CORED10_756 CORED11_758 CORED20_760 CORED21_762 CORED30_764 CORED31_766
+  NBL[0]_31 NBL[1]_31 NBL[2]_31 NBL[3]_31 NCORED00_768 NCORED01_770
+  NCORED10_772 NCORED11_774 NCORED20_776 NCORED21_778 NCORED30_780
+  NCORED31_782 VDDC_31 VDDCE_31 VDDPE_31 VNWC_32 VPW_32 VPW_0 WL[0] WL[1]
+  sram464x144CCHD4
XMEM_R_COL_32 BL[0]_32 BL[1]_32 BL[2]_32 BL[3]_32 CORED00_816 CORED01_818
+  CORED10_820 CORED11_822 CORED20_824 CORED21_826 CORED30_828 CORED31_830
+  NBL[0]_32 NBL[1]_32 NBL[2]_32 NBL[3]_32 NCORED00_832 NCORED01_834
+  NCORED10_836 NCORED11_838 NCORED20_840 NCORED21_842 NCORED30_844
+  NCORED31_846 VDDC_32 VDDCE_32 VDDPE_32 VNWC_33 VPW_33 VPW_0 WL[0] WL[1]
+  sram464x144CCHD4
XMEM_R_COL_33 BL[0]_33 BL[1]_33 BL[2]_33 BL[3]_33 CORED00_880 CORED01_882
+  CORED10_884 CORED11_886 CORED20_888 CORED21_890 CORED30_892 CORED31_894
+  NBL[0]_33 NBL[1]_33 NBL[2]_33 NBL[3]_33 NCORED00_896 NCORED01_898
+  NCORED10_900 NCORED11_902 NCORED20_904 NCORED21_906 NCORED30_908
+  NCORED31_910 VDDC_33 VDDCE_33 VDDPE_33 VNWC_34 VPW_34 VPW_0 WL[0] WL[1]
+  sram464x144CCHD4
XMEM_R_COL_34 BL[0]_34 BL[1]_34 BL[2]_34 BL[3]_34 CORED00_944 CORED01_946
+  CORED10_948 CORED11_950 CORED20_952 CORED21_954 CORED30_956 CORED31_958
+  NBL[0]_34 NBL[1]_34 NBL[2]_34 NBL[3]_34 NCORED00_960 NCORED01_962
+  NCORED10_964 NCORED11_966 NCORED20_968 NCORED21_970 NCORED30_972
+  NCORED31_974 VDDC_34 VDDCE_34 VDDPE_34 VNWC_35 VPW_35 VPW_0 WL[0] WL[1]
+  sram464x144CCHD4
XMEM_R_COL_35 BL[0]_35 BL[1]_35 BL[2]_35 BL[3]_35 CORED00_1008 CORED01_1010
+  CORED10_1012 CORED11_1014 CORED20_1016 CORED21_1018 CORED30_1020
+  CORED31_1022 NBL[0]_35 NBL[1]_35 NBL[2]_35 NBL[3]_35 NCORED00_1024
+  NCORED01_1026 NCORED10_1028 NCORED11_1030 NCORED20_1032 NCORED21_1034
+  NCORED30_1036 NCORED31_1038 VDDC_35 VDDCE_35 VDDPE_35 VNWC_36 VPW_36 VPW_0
+  WL[0] WL[1] sram464x144CCHD4
XMEM_R_COL_4 BL[0]_4 BL[1]_4 BL[2]_4 BL[3]_4 CORED00_432 CORED01_434
+  CORED10_436 CORED11_438 CORED20_440 CORED21_442 CORED30_444 CORED31_446
+  NBL[0]_4 NBL[1]_4 NBL[2]_4 NBL[3]_4 NCORED00_448 NCORED01_450 NCORED10_452
+  NCORED11_454 NCORED20_456 NCORED21_458 NCORED30_460 NCORED31_462 VDDC_4
+  VDDCE_4 VDDPE_4 VNWC_5 VPW_5 VPW_0 WL[0] WL[1] sram464x144CCHD4
XMEM_R_COL_5 BL[0]_5 BL[1]_5 BL[2]_5 BL[3]_5 CORED00_464 CORED01_466
+  CORED10_468 CORED11_470 CORED20_472 CORED21_474 CORED30_476 CORED31_478
+  NBL[0]_5 NBL[1]_5 NBL[2]_5 NBL[3]_5 NCORED00_480 NCORED01_482 NCORED10_484
+  NCORED11_486 NCORED20_488 NCORED21_490 NCORED30_492 NCORED31_494 VDDC_5
+  VDDCE_5 VDDPE_5 VNWC_6 VPW_6 VPW_0 WL[0] WL[1] sram464x144CCHD4
XMEM_R_COL_6 BL[0]_6 BL[1]_6 BL[2]_6 BL[3]_6 CORED00_496 CORED01_498
+  CORED10_500 CORED11_502 CORED20_504 CORED21_506 CORED30_508 CORED31_510
+  NBL[0]_6 NBL[1]_6 NBL[2]_6 NBL[3]_6 NCORED00_512 NCORED01_514 NCORED10_516
+  NCORED11_518 NCORED20_520 NCORED21_522 NCORED30_524 NCORED31_526 VDDC_6
+  VDDCE_6 VDDPE_6 VNWC_7 VPW_7 VPW_0 WL[0] WL[1] sram464x144CCHD4
XMEM_R_COL_7 BL[0]_7 BL[1]_7 BL[2]_7 BL[3]_7 CORED00_528 CORED01_530
+  CORED10_532 CORED11_534 CORED20_536 CORED21_538 CORED30_540 CORED31_542
+  NBL[0]_7 NBL[1]_7 NBL[2]_7 NBL[3]_7 NCORED00_544 NCORED01_546 NCORED10_548
+  NCORED11_550 NCORED20_552 NCORED21_554 NCORED30_556 NCORED31_558 VDDC_7
+  VDDCE_7 VDDPE_7 VNWC_8 VPW_8 VPW_0 WL[0] WL[1] sram464x144CCHD4
XMEM_R_COL_8 BL[0]_8 BL[1]_8 BL[2]_8 BL[3]_8 CORED00_560 CORED01_562
+  CORED10_564 CORED11_566 CORED20_568 CORED21_570 CORED30_572 CORED31_574
+  NBL[0]_8 NBL[1]_8 NBL[2]_8 NBL[3]_8 NCORED00_576 NCORED01_578 NCORED10_580
+  NCORED11_582 NCORED20_584 NCORED21_586 NCORED30_588 NCORED31_590 VDDC_8
+  VDDCE_8 VDDPE_8 VNWC_9 VPW_9 VPW_0 WL[0] WL[1] sram464x144CCHD4
XMEM_R_COL_9 BL[0]_9 BL[1]_9 BL[2]_9 BL[3]_9 CORED00_592 CORED01_594
+  CORED10_596 CORED11_598 CORED20_600 CORED21_602 CORED30_604 CORED31_606
+  NBL[0]_9 NBL[1]_9 NBL[2]_9 NBL[3]_9 NCORED00_608 NCORED01_610 NCORED10_612
+  NCORED11_614 NCORED20_616 NCORED21_618 NCORED30_620 NCORED31_622 VDDC_9
+  VDDCE_9 VDDPE_9 VNWC_10 VPW_10 VPW_0 WL[0] WL[1] sram464x144CCHD4
XMEM_R_COL_EDGEL VNWC_0 VNWP_0 VPW_0 VPW_0 WL[0] WL[1] sram464x144CCHD4WD_EDG
XMEM_R_COL_EDGER VNWC_37 VNWP_1 VPW_0 VPW_0 WL[0] WL[1] sram464x144CCHD4_EDG
.ENDS sram464x144MEM_R_MIDB_ROW
****
.SUBCKT sram464x144MEM_R_ROW BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5
+  BL[0]_6 BL[0]_7 BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13
+  BL[0]_14 BL[0]_15 BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21
+  BL[0]_22 BL[0]_23 BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29
+  BL[0]_30 BL[0]_31 BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1
+  BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10
+  BL[1]_11 BL[1]_12 BL[1]_13 BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18
+  BL[1]_19 BL[1]_20 BL[1]_21 BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26
+  BL[1]_27 BL[1]_28 BL[1]_29 BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34
+  BL[1]_35 BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7
+  BL[2]_8 BL[2]_9 BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15
+  BL[2]_16 BL[2]_17 BL[2]_18 BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23
+  BL[2]_24 BL[2]_25 BL[2]_26 BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31
+  BL[2]_32 BL[2]_33 BL[2]_34 BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4
+  BL[3]_5 BL[3]_6 BL[3]_7 BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13
+  BL[3]_14 BL[3]_15 BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21
+  BL[3]_22 BL[3]_23 BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29
+  BL[3]_30 BL[3]_31 BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1
+  NBL[0]_2 NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9
+  NBL[0]_10 NBL[0]_11 NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16
+  NBL[0]_17 NBL[0]_18 NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23
+  NBL[0]_24 NBL[0]_25 NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30
+  NBL[0]_31 NBL[0]_32 NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1
+  NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9
+  NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16
+  NBL[1]_17 NBL[1]_18 NBL[1]_19 NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23
+  NBL[1]_24 NBL[1]_25 NBL[1]_26 NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30
+  NBL[1]_31 NBL[1]_32 NBL[1]_33 NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1
+  NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9
+  NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13 NBL[2]_14 NBL[2]_15 NBL[2]_16
+  NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20 NBL[2]_21 NBL[2]_22 NBL[2]_23
+  NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27 NBL[2]_28 NBL[2]_29 NBL[2]_30
+  NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34 NBL[2]_35 NBL[3]_0 NBL[3]_1
+  NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 NBL[3]_8 NBL[3]_9
+  NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13 NBL[3]_14 NBL[3]_15 NBL[3]_16
+  NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20 NBL[3]_21 NBL[3]_22 NBL[3]_23
+  NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27 NBL[3]_28 NBL[3]_29 NBL[3]_30
+  NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34 NBL[3]_35 VDDCE_0 VDDCE_1 VDDCE_2
+  VDDCE_3 VDDCE_4 VDDCE_5 VDDCE_6 VDDCE_7 VDDCE_8 VDDCE_9 VDDCE_10 VDDCE_11
+  VDDCE_12 VDDCE_13 VDDCE_14 VDDCE_15 VDDCE_16 VDDCE_17 VDDCE_18 VDDCE_19
+  VDDCE_20 VDDCE_21 VDDCE_22 VDDCE_23 VDDCE_24 VDDCE_25 VDDCE_26 VDDCE_27
+  VDDCE_28 VDDCE_29 VDDCE_30 VDDCE_31 VDDCE_32 VDDCE_33 VDDCE_34 VDDCE_35
+  VDDC_0 VDDC_1 VDDC_2 VDDC_3 VDDC_4 VDDC_5 VDDC_6 VDDC_7 VDDC_8 VDDC_9
+  VDDC_10 VDDC_11 VDDC_12 VDDC_13 VDDC_14 VDDC_15 VDDC_16 VDDC_17 VDDC_18
+  VDDC_19 VDDC_20 VDDC_21 VDDC_22 VDDC_23 VDDC_24 VDDC_25 VDDC_26 VDDC_27
+  VDDC_28 VDDC_29 VDDC_30 VDDC_31 VDDC_32 VDDC_33 VDDC_34 VDDC_35 VDDPE_0
+  VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8 VDDPE_9
+  VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16 VDDPE_17
+  VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24 VDDPE_25
+  VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32 VDDPE_33
+  VDDPE_34 VDDPE_35 VNWC_0 VNWC_1 VNWC_2 VNWC_3 VNWC_4 VNWC_5 VNWC_6 VNWC_7
+  VNWC_8 VNWC_9 VNWC_10 VNWC_11 VNWC_12 VNWC_13 VNWC_14 VNWC_15 VNWC_16
+  VNWC_17 VNWC_18 VNWC_19 VNWC_20 VNWC_21 VNWC_22 VNWC_23 VNWC_24 VNWC_25
+  VNWC_26 VNWC_27 VNWC_28 VNWC_29 VNWC_30 VNWC_31 VNWC_32 VNWC_33 VNWC_34
+  VNWC_35 VNWC_36 VNWC_37 VNWP_0 VNWP_1 VPW_0 VPW_1 VPW_2 VPW_3 VPW_4 VPW_5
+  VPW_6 VPW_7 VPW_8 VPW_9 VPW_10 VPW_11 VPW_12 VPW_13 VPW_14 VPW_15 VPW_16
+  VPW_17 VPW_18 VPW_19 VPW_20 VPW_21 VPW_22 VPW_23 VPW_24 VPW_25 VPW_26
+  VPW_27 VPW_28 VPW_29 VPW_30 VPW_31 VPW_32 VPW_33 VPW_34 VPW_35 VPW_36 WL[0]
+  WL[1]
** sram464x144MEM_R_ROW: 1732 flat devices **
XMEM_R_COL_0 BL[0]_0 BL[1]_0 BL[2]_0 BL[3]_0 CORED00_304 CORED01_306
+  CORED10_308 CORED11_310 CORED20_312 CORED21_314 CORED30_316 CORED31_318
+  NBL[0]_0 NBL[1]_0 NBL[2]_0 NBL[3]_0 NCORED00_320 NCORED01_322 NCORED10_324
+  NCORED11_326 NCORED20_328 NCORED21_330 NCORED30_332 NCORED31_334 VDDC_0
+  VDDCE_0 VDDPE_0 VNWC_1 VPW_1 VPW_0 WL[0] WL[1] sram464x144CCHD4
XMEM_R_COL_1 BL[0]_1 BL[1]_1 BL[2]_1 BL[3]_1 CORED00_336 CORED01_338
+  CORED10_340 CORED11_342 CORED20_344 CORED21_346 CORED30_348 CORED31_350
+  NBL[0]_1 NBL[1]_1 NBL[2]_1 NBL[3]_1 NCORED00_352 NCORED01_354 NCORED10_356
+  NCORED11_358 NCORED20_360 NCORED21_362 NCORED30_364 NCORED31_366 VDDC_1
+  VDDCE_1 VDDPE_1 VNWC_2 VPW_2 VPW_0 WL[0] WL[1] sram464x144CCHD4
XMEM_R_COL_10 BL[0]_10 BL[1]_10 BL[2]_10 BL[3]_10 CORED00_624 CORED01_626
+  CORED10_628 CORED11_630 CORED20_632 CORED21_634 CORED30_636 CORED31_638
+  NBL[0]_10 NBL[1]_10 NBL[2]_10 NBL[3]_10 NCORED00_640 NCORED01_642
+  NCORED10_644 NCORED11_646 NCORED20_648 NCORED21_650 NCORED30_652
+  NCORED31_654 VDDC_10 VDDCE_10 VDDPE_10 VNWC_11 VPW_11 VPW_0 WL[0] WL[1]
+  sram464x144CCHD4
XMEM_R_COL_11 BL[0]_11 BL[1]_11 BL[2]_11 BL[3]_11 CORED00_656 CORED01_658
+  CORED10_660 CORED11_662 CORED20_664 CORED21_666 CORED30_668 CORED31_670
+  NBL[0]_11 NBL[1]_11 NBL[2]_11 NBL[3]_11 NCORED00_672 NCORED01_674
+  NCORED10_676 NCORED11_678 NCORED20_680 NCORED21_682 NCORED30_684
+  NCORED31_686 VDDC_11 VDDCE_11 VDDPE_11 VNWC_12 VPW_12 VPW_0 WL[0] WL[1]
+  sram464x144CCHD4
XMEM_R_COL_12 BL[0]_12 BL[1]_12 BL[2]_12 BL[3]_12 CORED00_688 CORED01_690
+  CORED10_692 CORED11_694 CORED20_696 CORED21_698 CORED30_700 CORED31_702
+  NBL[0]_12 NBL[1]_12 NBL[2]_12 NBL[3]_12 NCORED00_704 NCORED01_706
+  NCORED10_708 NCORED11_710 NCORED20_712 NCORED21_714 NCORED30_716
+  NCORED31_718 VDDC_12 VDDCE_12 VDDPE_12 VNWC_13 VPW_13 VPW_0 WL[0] WL[1]
+  sram464x144CCHD4
XMEM_R_COL_13 BL[0]_13 BL[1]_13 BL[2]_13 BL[3]_13 CORED00_784 CORED01_786
+  CORED10_788 CORED11_790 CORED20_792 CORED21_794 CORED30_796 CORED31_798
+  NBL[0]_13 NBL[1]_13 NBL[2]_13 NBL[3]_13 NCORED00_800 NCORED01_802
+  NCORED10_804 NCORED11_806 NCORED20_808 NCORED21_810 NCORED30_812
+  NCORED31_814 VDDC_13 VDDCE_13 VDDPE_13 VNWC_14 VPW_14 VPW_0 WL[0] WL[1]
+  sram464x144CCHD4
XMEM_R_COL_14 BL[0]_14 BL[1]_14 BL[2]_14 BL[3]_14 CORED00_848 CORED01_850
+  CORED10_852 CORED11_854 CORED20_856 CORED21_858 CORED30_860 CORED31_862
+  NBL[0]_14 NBL[1]_14 NBL[2]_14 NBL[3]_14 NCORED00_864 NCORED01_866
+  NCORED10_868 NCORED11_870 NCORED20_872 NCORED21_874 NCORED30_876
+  NCORED31_878 VDDC_14 VDDCE_14 VDDPE_14 VNWC_15 VPW_15 VPW_0 WL[0] WL[1]
+  sram464x144CCHD4
XMEM_R_COL_15 BL[0]_15 BL[1]_15 BL[2]_15 BL[3]_15 CORED00_912 CORED01_914
+  CORED10_916 CORED11_918 CORED20_920 CORED21_922 CORED30_924 CORED31_926
+  NBL[0]_15 NBL[1]_15 NBL[2]_15 NBL[3]_15 NCORED00_928 NCORED01_930
+  NCORED10_932 NCORED11_934 NCORED20_936 NCORED21_938 NCORED30_940
+  NCORED31_942 VDDC_15 VDDCE_15 VDDPE_15 VNWC_16 VPW_16 VPW_0 WL[0] WL[1]
+  sram464x144CCHD4
XMEM_R_COL_16 BL[0]_16 BL[1]_16 BL[2]_16 BL[3]_16 CORED00_976 CORED01_978
+  CORED10_980 CORED11_982 CORED20_984 CORED21_986 CORED30_988 CORED31_990
+  NBL[0]_16 NBL[1]_16 NBL[2]_16 NBL[3]_16 NCORED00_992 NCORED01_994
+  NCORED10_996 NCORED11_998 NCORED20_1000 NCORED21_1002 NCORED30_1004
+  NCORED31_1006 VDDC_16 VDDCE_16 VDDPE_16 VNWC_17 VPW_17 VPW_0 WL[0] WL[1]
+  sram464x144CCHD4
XMEM_R_COL_17 BL[0]_17 BL[1]_17 BL[2]_17 BL[3]_17 CORED00_1040 CORED01_1042
+  CORED10_1044 CORED11_1046 CORED20_1048 CORED21_1050 CORED30_1052
+  CORED31_1054 NBL[0]_17 NBL[1]_17 NBL[2]_17 NBL[3]_17 NCORED00_1056
+  NCORED01_1058 NCORED10_1060 NCORED11_1062 NCORED20_1064 NCORED21_1066
+  NCORED30_1068 NCORED31_1070 VDDC_17 VDDCE_17 VDDPE_17 VNWC_18 VPW_18 VPW_0
+  WL[0] WL[1] sram464x144CCHD4
XMEM_R_COL_18 BL[0]_18 BL[1]_18 BL[2]_18 BL[3]_18 CORED00_1072 CORED01_1074
+  CORED10_1076 CORED11_1078 CORED20_1080 CORED21_1082 CORED30_1084
+  CORED31_1086 NBL[0]_18 NBL[1]_18 NBL[2]_18 NBL[3]_18 NCORED00_1088
+  NCORED01_1090 NCORED10_1092 NCORED11_1094 NCORED20_1096 NCORED21_1098
+  NCORED30_1100 NCORED31_1102 VDDC_18 VDDCE_18 VDDPE_18 VNWC_19 VPW_19 VPW_0
+  WL[0] WL[1] sram464x144CCHD4
XMEM_R_COL_19 BL[0]_19 BL[1]_19 BL[2]_19 BL[3]_19 CORED00_1104 CORED01_1106
+  CORED10_1108 CORED11_1110 CORED20_1112 CORED21_1114 CORED30_1116
+  CORED31_1118 NBL[0]_19 NBL[1]_19 NBL[2]_19 NBL[3]_19 NCORED00_1120
+  NCORED01_1122 NCORED10_1124 NCORED11_1126 NCORED20_1128 NCORED21_1130
+  NCORED30_1132 NCORED31_1134 VDDC_19 VDDCE_19 VDDPE_19 VNWC_20 VPW_20 VPW_0
+  WL[0] WL[1] sram464x144CCHD4
XMEM_R_COL_2 BL[0]_2 BL[1]_2 BL[2]_2 BL[3]_2 CORED00_368 CORED01_370
+  CORED10_372 CORED11_374 CORED20_376 CORED21_378 CORED30_380 CORED31_382
+  NBL[0]_2 NBL[1]_2 NBL[2]_2 NBL[3]_2 NCORED00_384 NCORED01_386 NCORED10_388
+  NCORED11_390 NCORED20_392 NCORED21_394 NCORED30_396 NCORED31_398 VDDC_2
+  VDDCE_2 VDDPE_2 VNWC_3 VPW_3 VPW_0 WL[0] WL[1] sram464x144CCHD4
XMEM_R_COL_20 BL[0]_20 BL[1]_20 BL[2]_20 BL[3]_20 CORED00 CORED01 CORED10
+  CORED11 CORED20 CORED21 CORED30 CORED31 NBL[0]_20 NBL[1]_20 NBL[2]_20
+  NBL[3]_20 NCORED00 NCORED01 NCORED10 NCORED11 NCORED20 NCORED21 NCORED30
+  NCORED31 VDDC_20 VDDCE_20 VDDPE_20 VNWC_21 VPW_21 VPW_0 WL[0] WL[1]
+  sram464x144CCHD4
XMEM_R_COL_21 BL[0]_21 BL[1]_21 BL[2]_21 BL[3]_21 CORED00_16 CORED01_18
+  CORED10_20 CORED11_22 CORED20_24 CORED21_26 CORED30_28 CORED31_30 NBL[0]_21
+  NBL[1]_21 NBL[2]_21 NBL[3]_21 NCORED00_32 NCORED01_34 NCORED10_36
+  NCORED11_38 NCORED20_40 NCORED21_42 NCORED30_44 NCORED31_46 VDDC_21
+  VDDCE_21 VDDPE_21 VNWC_22 VPW_22 VPW_0 WL[0] WL[1] sram464x144CCHD4
XMEM_R_COL_22 BL[0]_22 BL[1]_22 BL[2]_22 BL[3]_22 CORED00_48 CORED01_50
+  CORED10_52 CORED11_54 CORED20_56 CORED21_58 CORED30_60 CORED31_62 NBL[0]_22
+  NBL[1]_22 NBL[2]_22 NBL[3]_22 NCORED00_64 NCORED01_66 NCORED10_68
+  NCORED11_70 NCORED20_72 NCORED21_74 NCORED30_76 NCORED31_78 VDDC_22
+  VDDCE_22 VDDPE_22 VNWC_23 VPW_23 VPW_0 WL[0] WL[1] sram464x144CCHD4
XMEM_R_COL_23 BL[0]_23 BL[1]_23 BL[2]_23 BL[3]_23 CORED00_80 CORED01_82
+  CORED10_84 CORED11_86 CORED20_88 CORED21_90 CORED30_92 CORED31_94 NBL[0]_23
+  NBL[1]_23 NBL[2]_23 NBL[3]_23 NCORED00_96 NCORED01_98 NCORED10_100
+  NCORED11_102 NCORED20_104 NCORED21_106 NCORED30_108 NCORED31_110 VDDC_23
+  VDDCE_23 VDDPE_23 VNWC_24 VPW_24 VPW_0 WL[0] WL[1] sram464x144CCHD4
XMEM_R_COL_24 BL[0]_24 BL[1]_24 BL[2]_24 BL[3]_24 CORED00_112 CORED01_114
+  CORED10_116 CORED11_118 CORED20_120 CORED21_122 CORED30_124 CORED31_126
+  NBL[0]_24 NBL[1]_24 NBL[2]_24 NBL[3]_24 NCORED00_128 NCORED01_130
+  NCORED10_132 NCORED11_134 NCORED20_136 NCORED21_138 NCORED30_140
+  NCORED31_142 VDDC_24 VDDCE_24 VDDPE_24 VNWC_25 VPW_25 VPW_0 WL[0] WL[1]
+  sram464x144CCHD4
XMEM_R_COL_25 BL[0]_25 BL[1]_25 BL[2]_25 BL[3]_25 CORED00_144 CORED01_146
+  CORED10_148 CORED11_150 CORED20_152 CORED21_154 CORED30_156 CORED31_158
+  NBL[0]_25 NBL[1]_25 NBL[2]_25 NBL[3]_25 NCORED00_160 NCORED01_162
+  NCORED10_164 NCORED11_166 NCORED20_168 NCORED21_170 NCORED30_172
+  NCORED31_174 VDDC_25 VDDCE_25 VDDPE_25 VNWC_26 VPW_26 VPW_0 WL[0] WL[1]
+  sram464x144CCHD4
XMEM_R_COL_26 BL[0]_26 BL[1]_26 BL[2]_26 BL[3]_26 CORED00_176 CORED01_178
+  CORED10_180 CORED11_182 CORED20_184 CORED21_186 CORED30_188 CORED31_190
+  NBL[0]_26 NBL[1]_26 NBL[2]_26 NBL[3]_26 NCORED00_192 NCORED01_194
+  NCORED10_196 NCORED11_198 NCORED20_200 NCORED21_202 NCORED30_204
+  NCORED31_206 VDDC_26 VDDCE_26 VDDPE_26 VNWC_27 VPW_27 VPW_0 WL[0] WL[1]
+  sram464x144CCHD4
XMEM_R_COL_27 BL[0]_27 BL[1]_27 BL[2]_27 BL[3]_27 CORED00_208 CORED01_210
+  CORED10_212 CORED11_214 CORED20_216 CORED21_218 CORED30_220 CORED31_222
+  NBL[0]_27 NBL[1]_27 NBL[2]_27 NBL[3]_27 NCORED00_224 NCORED01_226
+  NCORED10_228 NCORED11_230 NCORED20_232 NCORED21_234 NCORED30_236
+  NCORED31_238 VDDC_27 VDDCE_27 VDDPE_27 VNWC_28 VPW_28 VPW_0 WL[0] WL[1]
+  sram464x144CCHD4
XMEM_R_COL_28 BL[0]_28 BL[1]_28 BL[2]_28 BL[3]_28 CORED00_240 CORED01_242
+  CORED10_244 CORED11_246 CORED20_248 CORED21_250 CORED30_252 CORED31_254
+  NBL[0]_28 NBL[1]_28 NBL[2]_28 NBL[3]_28 NCORED00_256 NCORED01_258
+  NCORED10_260 NCORED11_262 NCORED20_264 NCORED21_266 NCORED30_268
+  NCORED31_270 VDDC_28 VDDCE_28 VDDPE_28 VNWC_29 VPW_29 VPW_0 WL[0] WL[1]
+  sram464x144CCHD4
XMEM_R_COL_29 BL[0]_29 BL[1]_29 BL[2]_29 BL[3]_29 CORED00_272 CORED01_274
+  CORED10_276 CORED11_278 CORED20_280 CORED21_282 CORED30_284 CORED31_286
+  NBL[0]_29 NBL[1]_29 NBL[2]_29 NBL[3]_29 NCORED00_288 NCORED01_290
+  NCORED10_292 NCORED11_294 NCORED20_296 NCORED21_298 NCORED30_300
+  NCORED31_302 VDDC_29 VDDCE_29 VDDPE_29 VNWC_30 VPW_30 VPW_0 WL[0] WL[1]
+  sram464x144CCHD4
XMEM_R_COL_3 BL[0]_3 BL[1]_3 BL[2]_3 BL[3]_3 CORED00_400 CORED01_402
+  CORED10_404 CORED11_406 CORED20_408 CORED21_410 CORED30_412 CORED31_414
+  NBL[0]_3 NBL[1]_3 NBL[2]_3 NBL[3]_3 NCORED00_416 NCORED01_418 NCORED10_420
+  NCORED11_422 NCORED20_424 NCORED21_426 NCORED30_428 NCORED31_430 VDDC_3
+  VDDCE_3 VDDPE_3 VNWC_4 VPW_4 VPW_0 WL[0] WL[1] sram464x144CCHD4
XMEM_R_COL_30 BL[0]_30 BL[1]_30 BL[2]_30 BL[3]_30 CORED00_720 CORED01_722
+  CORED10_724 CORED11_726 CORED20_728 CORED21_730 CORED30_732 CORED31_734
+  NBL[0]_30 NBL[1]_30 NBL[2]_30 NBL[3]_30 NCORED00_736 NCORED01_738
+  NCORED10_740 NCORED11_742 NCORED20_744 NCORED21_746 NCORED30_748
+  NCORED31_750 VDDC_30 VDDCE_30 VDDPE_30 VNWC_31 VPW_31 VPW_0 WL[0] WL[1]
+  sram464x144CCHD4
XMEM_R_COL_31 BL[0]_31 BL[1]_31 BL[2]_31 BL[3]_31 CORED00_752 CORED01_754
+  CORED10_756 CORED11_758 CORED20_760 CORED21_762 CORED30_764 CORED31_766
+  NBL[0]_31 NBL[1]_31 NBL[2]_31 NBL[3]_31 NCORED00_768 NCORED01_770
+  NCORED10_772 NCORED11_774 NCORED20_776 NCORED21_778 NCORED30_780
+  NCORED31_782 VDDC_31 VDDCE_31 VDDPE_31 VNWC_32 VPW_32 VPW_0 WL[0] WL[1]
+  sram464x144CCHD4
XMEM_R_COL_32 BL[0]_32 BL[1]_32 BL[2]_32 BL[3]_32 CORED00_816 CORED01_818
+  CORED10_820 CORED11_822 CORED20_824 CORED21_826 CORED30_828 CORED31_830
+  NBL[0]_32 NBL[1]_32 NBL[2]_32 NBL[3]_32 NCORED00_832 NCORED01_834
+  NCORED10_836 NCORED11_838 NCORED20_840 NCORED21_842 NCORED30_844
+  NCORED31_846 VDDC_32 VDDCE_32 VDDPE_32 VNWC_33 VPW_33 VPW_0 WL[0] WL[1]
+  sram464x144CCHD4
XMEM_R_COL_33 BL[0]_33 BL[1]_33 BL[2]_33 BL[3]_33 CORED00_880 CORED01_882
+  CORED10_884 CORED11_886 CORED20_888 CORED21_890 CORED30_892 CORED31_894
+  NBL[0]_33 NBL[1]_33 NBL[2]_33 NBL[3]_33 NCORED00_896 NCORED01_898
+  NCORED10_900 NCORED11_902 NCORED20_904 NCORED21_906 NCORED30_908
+  NCORED31_910 VDDC_33 VDDCE_33 VDDPE_33 VNWC_34 VPW_34 VPW_0 WL[0] WL[1]
+  sram464x144CCHD4
XMEM_R_COL_34 BL[0]_34 BL[1]_34 BL[2]_34 BL[3]_34 CORED00_944 CORED01_946
+  CORED10_948 CORED11_950 CORED20_952 CORED21_954 CORED30_956 CORED31_958
+  NBL[0]_34 NBL[1]_34 NBL[2]_34 NBL[3]_34 NCORED00_960 NCORED01_962
+  NCORED10_964 NCORED11_966 NCORED20_968 NCORED21_970 NCORED30_972
+  NCORED31_974 VDDC_34 VDDCE_34 VDDPE_34 VNWC_35 VPW_35 VPW_0 WL[0] WL[1]
+  sram464x144CCHD4
XMEM_R_COL_35 BL[0]_35 BL[1]_35 BL[2]_35 BL[3]_35 CORED00_1008 CORED01_1010
+  CORED10_1012 CORED11_1014 CORED20_1016 CORED21_1018 CORED30_1020
+  CORED31_1022 NBL[0]_35 NBL[1]_35 NBL[2]_35 NBL[3]_35 NCORED00_1024
+  NCORED01_1026 NCORED10_1028 NCORED11_1030 NCORED20_1032 NCORED21_1034
+  NCORED30_1036 NCORED31_1038 VDDC_35 VDDCE_35 VDDPE_35 VNWC_36 VPW_36 VPW_0
+  WL[0] WL[1] sram464x144CCHD4
XMEM_R_COL_4 BL[0]_4 BL[1]_4 BL[2]_4 BL[3]_4 CORED00_432 CORED01_434
+  CORED10_436 CORED11_438 CORED20_440 CORED21_442 CORED30_444 CORED31_446
+  NBL[0]_4 NBL[1]_4 NBL[2]_4 NBL[3]_4 NCORED00_448 NCORED01_450 NCORED10_452
+  NCORED11_454 NCORED20_456 NCORED21_458 NCORED30_460 NCORED31_462 VDDC_4
+  VDDCE_4 VDDPE_4 VNWC_5 VPW_5 VPW_0 WL[0] WL[1] sram464x144CCHD4
XMEM_R_COL_5 BL[0]_5 BL[1]_5 BL[2]_5 BL[3]_5 CORED00_464 CORED01_466
+  CORED10_468 CORED11_470 CORED20_472 CORED21_474 CORED30_476 CORED31_478
+  NBL[0]_5 NBL[1]_5 NBL[2]_5 NBL[3]_5 NCORED00_480 NCORED01_482 NCORED10_484
+  NCORED11_486 NCORED20_488 NCORED21_490 NCORED30_492 NCORED31_494 VDDC_5
+  VDDCE_5 VDDPE_5 VNWC_6 VPW_6 VPW_0 WL[0] WL[1] sram464x144CCHD4
XMEM_R_COL_6 BL[0]_6 BL[1]_6 BL[2]_6 BL[3]_6 CORED00_496 CORED01_498
+  CORED10_500 CORED11_502 CORED20_504 CORED21_506 CORED30_508 CORED31_510
+  NBL[0]_6 NBL[1]_6 NBL[2]_6 NBL[3]_6 NCORED00_512 NCORED01_514 NCORED10_516
+  NCORED11_518 NCORED20_520 NCORED21_522 NCORED30_524 NCORED31_526 VDDC_6
+  VDDCE_6 VDDPE_6 VNWC_7 VPW_7 VPW_0 WL[0] WL[1] sram464x144CCHD4
XMEM_R_COL_7 BL[0]_7 BL[1]_7 BL[2]_7 BL[3]_7 CORED00_528 CORED01_530
+  CORED10_532 CORED11_534 CORED20_536 CORED21_538 CORED30_540 CORED31_542
+  NBL[0]_7 NBL[1]_7 NBL[2]_7 NBL[3]_7 NCORED00_544 NCORED01_546 NCORED10_548
+  NCORED11_550 NCORED20_552 NCORED21_554 NCORED30_556 NCORED31_558 VDDC_7
+  VDDCE_7 VDDPE_7 VNWC_8 VPW_8 VPW_0 WL[0] WL[1] sram464x144CCHD4
XMEM_R_COL_8 BL[0]_8 BL[1]_8 BL[2]_8 BL[3]_8 CORED00_560 CORED01_562
+  CORED10_564 CORED11_566 CORED20_568 CORED21_570 CORED30_572 CORED31_574
+  NBL[0]_8 NBL[1]_8 NBL[2]_8 NBL[3]_8 NCORED00_576 NCORED01_578 NCORED10_580
+  NCORED11_582 NCORED20_584 NCORED21_586 NCORED30_588 NCORED31_590 VDDC_8
+  VDDCE_8 VDDPE_8 VNWC_9 VPW_9 VPW_0 WL[0] WL[1] sram464x144CCHD4
XMEM_R_COL_9 BL[0]_9 BL[1]_9 BL[2]_9 BL[3]_9 CORED00_592 CORED01_594
+  CORED10_596 CORED11_598 CORED20_600 CORED21_602 CORED30_604 CORED31_606
+  NBL[0]_9 NBL[1]_9 NBL[2]_9 NBL[3]_9 NCORED00_608 NCORED01_610 NCORED10_612
+  NCORED11_614 NCORED20_616 NCORED21_618 NCORED30_620 NCORED31_622 VDDC_9
+  VDDCE_9 VDDPE_9 VNWC_10 VPW_10 VPW_0 WL[0] WL[1] sram464x144CCHD4
XMEM_R_COL_EDGEL VNWC_0 VNWP_0 VPW_0 VPW_0 WL[0] WL[1] sram464x144CCHD4WD_EDG
XMEM_R_COL_EDGER VNWC_37 VNWP_1 VPW_0 VPW_0 WL[0] WL[1] sram464x144CCHD4_EDG
.ENDS sram464x144MEM_R_ROW
****
.SUBCKT sram464x144MEM_R_MIDT_ROW BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4
+  BL[0]_5 BL[0]_6 BL[0]_7 BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13
+  BL[0]_14 BL[0]_15 BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21
+  BL[0]_22 BL[0]_23 BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29
+  BL[0]_30 BL[0]_31 BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1
+  BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10
+  BL[1]_11 BL[1]_12 BL[1]_13 BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18
+  BL[1]_19 BL[1]_20 BL[1]_21 BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26
+  BL[1]_27 BL[1]_28 BL[1]_29 BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34
+  BL[1]_35 BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7
+  BL[2]_8 BL[2]_9 BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15
+  BL[2]_16 BL[2]_17 BL[2]_18 BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23
+  BL[2]_24 BL[2]_25 BL[2]_26 BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31
+  BL[2]_32 BL[2]_33 BL[2]_34 BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4
+  BL[3]_5 BL[3]_6 BL[3]_7 BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13
+  BL[3]_14 BL[3]_15 BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21
+  BL[3]_22 BL[3]_23 BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29
+  BL[3]_30 BL[3]_31 BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1
+  NBL[0]_2 NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9
+  NBL[0]_10 NBL[0]_11 NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16
+  NBL[0]_17 NBL[0]_18 NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23
+  NBL[0]_24 NBL[0]_25 NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30
+  NBL[0]_31 NBL[0]_32 NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1
+  NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9
+  NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16
+  NBL[1]_17 NBL[1]_18 NBL[1]_19 NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23
+  NBL[1]_24 NBL[1]_25 NBL[1]_26 NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30
+  NBL[1]_31 NBL[1]_32 NBL[1]_33 NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1
+  NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9
+  NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13 NBL[2]_14 NBL[2]_15 NBL[2]_16
+  NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20 NBL[2]_21 NBL[2]_22 NBL[2]_23
+  NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27 NBL[2]_28 NBL[2]_29 NBL[2]_30
+  NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34 NBL[2]_35 NBL[3]_0 NBL[3]_1
+  NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 NBL[3]_8 NBL[3]_9
+  NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13 NBL[3]_14 NBL[3]_15 NBL[3]_16
+  NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20 NBL[3]_21 NBL[3]_22 NBL[3]_23
+  NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27 NBL[3]_28 NBL[3]_29 NBL[3]_30
+  NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34 NBL[3]_35 VDDCE_0 VDDCE_1 VDDCE_2
+  VDDCE_3 VDDCE_4 VDDCE_5 VDDCE_6 VDDCE_7 VDDCE_8 VDDCE_9 VDDCE_10 VDDCE_11
+  VDDCE_12 VDDCE_13 VDDCE_14 VDDCE_15 VDDCE_16 VDDCE_17 VDDCE_18 VDDCE_19
+  VDDCE_20 VDDCE_21 VDDCE_22 VDDCE_23 VDDCE_24 VDDCE_25 VDDCE_26 VDDCE_27
+  VDDCE_28 VDDCE_29 VDDCE_30 VDDCE_31 VDDCE_32 VDDCE_33 VDDCE_34 VDDCE_35
+  VDDC_0 VDDC_1 VDDC_2 VDDC_3 VDDC_4 VDDC_5 VDDC_6 VDDC_7 VDDC_8 VDDC_9
+  VDDC_10 VDDC_11 VDDC_12 VDDC_13 VDDC_14 VDDC_15 VDDC_16 VDDC_17 VDDC_18
+  VDDC_19 VDDC_20 VDDC_21 VDDC_22 VDDC_23 VDDC_24 VDDC_25 VDDC_26 VDDC_27
+  VDDC_28 VDDC_29 VDDC_30 VDDC_31 VDDC_32 VDDC_33 VDDC_34 VDDC_35 VDDPE_0
+  VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8 VDDPE_9
+  VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16 VDDPE_17
+  VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24 VDDPE_25
+  VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32 VDDPE_33
+  VDDPE_34 VDDPE_35 VNWC_0 VNWC_1 VNWC_2 VNWC_3 VNWC_4 VNWC_5 VNWC_6 VNWC_7
+  VNWC_8 VNWC_9 VNWC_10 VNWC_11 VNWC_12 VNWC_13 VNWC_14 VNWC_15 VNWC_16
+  VNWC_17 VNWC_18 VNWC_19 VNWC_20 VNWC_21 VNWC_22 VNWC_23 VNWC_24 VNWC_25
+  VNWC_26 VNWC_27 VNWC_28 VNWC_29 VNWC_30 VNWC_31 VNWC_32 VNWC_33 VNWC_34
+  VNWC_35 VNWC_36 VNWC_37 VNWP_0 VNWP_1 VPW_0 VPW_1 VPW_2 VPW_3 VPW_4 VPW_5
+  VPW_6 VPW_7 VPW_8 VPW_9 VPW_10 VPW_11 VPW_12 VPW_13 VPW_14 VPW_15 VPW_16
+  VPW_17 VPW_18 VPW_19 VPW_20 VPW_21 VPW_22 VPW_23 VPW_24 VPW_25 VPW_26
+  VPW_27 VPW_28 VPW_29 VPW_30 VPW_31 VPW_32 VPW_33 VPW_34 VPW_35 VPW_36 WL[0]
+  WL[1]
** sram464x144MEM_R_MIDT_ROW: 1732 flat devices **
XMEM_R_COL_0 BL[0]_0 BL[1]_0 BL[2]_0 BL[3]_0 CORED00_304 CORED01_306
+  CORED10_308 CORED11_310 CORED20_312 CORED21_314 CORED30_316 CORED31_318
+  NBL[0]_0 NBL[1]_0 NBL[2]_0 NBL[3]_0 NCORED00_320 NCORED01_322 NCORED10_324
+  NCORED11_326 NCORED20_328 NCORED21_330 NCORED30_332 NCORED31_334 VDDC_0
+  VDDCE_0 VDDPE_0 VNWC_1 VPW_1 VPW_0 WL[0] WL[1] sram464x144CCHD4
XMEM_R_COL_1 BL[0]_1 BL[1]_1 BL[2]_1 BL[3]_1 CORED00_336 CORED01_338
+  CORED10_340 CORED11_342 CORED20_344 CORED21_346 CORED30_348 CORED31_350
+  NBL[0]_1 NBL[1]_1 NBL[2]_1 NBL[3]_1 NCORED00_352 NCORED01_354 NCORED10_356
+  NCORED11_358 NCORED20_360 NCORED21_362 NCORED30_364 NCORED31_366 VDDC_1
+  VDDCE_1 VDDPE_1 VNWC_2 VPW_2 VPW_0 WL[0] WL[1] sram464x144CCHD4
XMEM_R_COL_10 BL[0]_10 BL[1]_10 BL[2]_10 BL[3]_10 CORED00_624 CORED01_626
+  CORED10_628 CORED11_630 CORED20_632 CORED21_634 CORED30_636 CORED31_638
+  NBL[0]_10 NBL[1]_10 NBL[2]_10 NBL[3]_10 NCORED00_640 NCORED01_642
+  NCORED10_644 NCORED11_646 NCORED20_648 NCORED21_650 NCORED30_652
+  NCORED31_654 VDDC_10 VDDCE_10 VDDPE_10 VNWC_11 VPW_11 VPW_0 WL[0] WL[1]
+  sram464x144CCHD4
XMEM_R_COL_11 BL[0]_11 BL[1]_11 BL[2]_11 BL[3]_11 CORED00_656 CORED01_658
+  CORED10_660 CORED11_662 CORED20_664 CORED21_666 CORED30_668 CORED31_670
+  NBL[0]_11 NBL[1]_11 NBL[2]_11 NBL[3]_11 NCORED00_672 NCORED01_674
+  NCORED10_676 NCORED11_678 NCORED20_680 NCORED21_682 NCORED30_684
+  NCORED31_686 VDDC_11 VDDCE_11 VDDPE_11 VNWC_12 VPW_12 VPW_0 WL[0] WL[1]
+  sram464x144CCHD4
XMEM_R_COL_12 BL[0]_12 BL[1]_12 BL[2]_12 BL[3]_12 CORED00_688 CORED01_690
+  CORED10_692 CORED11_694 CORED20_696 CORED21_698 CORED30_700 CORED31_702
+  NBL[0]_12 NBL[1]_12 NBL[2]_12 NBL[3]_12 NCORED00_704 NCORED01_706
+  NCORED10_708 NCORED11_710 NCORED20_712 NCORED21_714 NCORED30_716
+  NCORED31_718 VDDC_12 VDDCE_12 VDDPE_12 VNWC_13 VPW_13 VPW_0 WL[0] WL[1]
+  sram464x144CCHD4
XMEM_R_COL_13 BL[0]_13 BL[1]_13 BL[2]_13 BL[3]_13 CORED00_784 CORED01_786
+  CORED10_788 CORED11_790 CORED20_792 CORED21_794 CORED30_796 CORED31_798
+  NBL[0]_13 NBL[1]_13 NBL[2]_13 NBL[3]_13 NCORED00_800 NCORED01_802
+  NCORED10_804 NCORED11_806 NCORED20_808 NCORED21_810 NCORED30_812
+  NCORED31_814 VDDC_13 VDDCE_13 VDDPE_13 VNWC_14 VPW_14 VPW_0 WL[0] WL[1]
+  sram464x144CCHD4
XMEM_R_COL_14 BL[0]_14 BL[1]_14 BL[2]_14 BL[3]_14 CORED00_848 CORED01_850
+  CORED10_852 CORED11_854 CORED20_856 CORED21_858 CORED30_860 CORED31_862
+  NBL[0]_14 NBL[1]_14 NBL[2]_14 NBL[3]_14 NCORED00_864 NCORED01_866
+  NCORED10_868 NCORED11_870 NCORED20_872 NCORED21_874 NCORED30_876
+  NCORED31_878 VDDC_14 VDDCE_14 VDDPE_14 VNWC_15 VPW_15 VPW_0 WL[0] WL[1]
+  sram464x144CCHD4
XMEM_R_COL_15 BL[0]_15 BL[1]_15 BL[2]_15 BL[3]_15 CORED00_912 CORED01_914
+  CORED10_916 CORED11_918 CORED20_920 CORED21_922 CORED30_924 CORED31_926
+  NBL[0]_15 NBL[1]_15 NBL[2]_15 NBL[3]_15 NCORED00_928 NCORED01_930
+  NCORED10_932 NCORED11_934 NCORED20_936 NCORED21_938 NCORED30_940
+  NCORED31_942 VDDC_15 VDDCE_15 VDDPE_15 VNWC_16 VPW_16 VPW_0 WL[0] WL[1]
+  sram464x144CCHD4
XMEM_R_COL_16 BL[0]_16 BL[1]_16 BL[2]_16 BL[3]_16 CORED00_976 CORED01_978
+  CORED10_980 CORED11_982 CORED20_984 CORED21_986 CORED30_988 CORED31_990
+  NBL[0]_16 NBL[1]_16 NBL[2]_16 NBL[3]_16 NCORED00_992 NCORED01_994
+  NCORED10_996 NCORED11_998 NCORED20_1000 NCORED21_1002 NCORED30_1004
+  NCORED31_1006 VDDC_16 VDDCE_16 VDDPE_16 VNWC_17 VPW_17 VPW_0 WL[0] WL[1]
+  sram464x144CCHD4
XMEM_R_COL_17 BL[0]_17 BL[1]_17 BL[2]_17 BL[3]_17 CORED00_1040 CORED01_1042
+  CORED10_1044 CORED11_1046 CORED20_1048 CORED21_1050 CORED30_1052
+  CORED31_1054 NBL[0]_17 NBL[1]_17 NBL[2]_17 NBL[3]_17 NCORED00_1056
+  NCORED01_1058 NCORED10_1060 NCORED11_1062 NCORED20_1064 NCORED21_1066
+  NCORED30_1068 NCORED31_1070 VDDC_17 VDDCE_17 VDDPE_17 VNWC_18 VPW_18 VPW_0
+  WL[0] WL[1] sram464x144CCHD4
XMEM_R_COL_18 BL[0]_18 BL[1]_18 BL[2]_18 BL[3]_18 CORED00_1072 CORED01_1074
+  CORED10_1076 CORED11_1078 CORED20_1080 CORED21_1082 CORED30_1084
+  CORED31_1086 NBL[0]_18 NBL[1]_18 NBL[2]_18 NBL[3]_18 NCORED00_1088
+  NCORED01_1090 NCORED10_1092 NCORED11_1094 NCORED20_1096 NCORED21_1098
+  NCORED30_1100 NCORED31_1102 VDDC_18 VDDCE_18 VDDPE_18 VNWC_19 VPW_19 VPW_0
+  WL[0] WL[1] sram464x144CCHD4
XMEM_R_COL_19 BL[0]_19 BL[1]_19 BL[2]_19 BL[3]_19 CORED00_1104 CORED01_1106
+  CORED10_1108 CORED11_1110 CORED20_1112 CORED21_1114 CORED30_1116
+  CORED31_1118 NBL[0]_19 NBL[1]_19 NBL[2]_19 NBL[3]_19 NCORED00_1120
+  NCORED01_1122 NCORED10_1124 NCORED11_1126 NCORED20_1128 NCORED21_1130
+  NCORED30_1132 NCORED31_1134 VDDC_19 VDDCE_19 VDDPE_19 VNWC_20 VPW_20 VPW_0
+  WL[0] WL[1] sram464x144CCHD4
XMEM_R_COL_2 BL[0]_2 BL[1]_2 BL[2]_2 BL[3]_2 CORED00_368 CORED01_370
+  CORED10_372 CORED11_374 CORED20_376 CORED21_378 CORED30_380 CORED31_382
+  NBL[0]_2 NBL[1]_2 NBL[2]_2 NBL[3]_2 NCORED00_384 NCORED01_386 NCORED10_388
+  NCORED11_390 NCORED20_392 NCORED21_394 NCORED30_396 NCORED31_398 VDDC_2
+  VDDCE_2 VDDPE_2 VNWC_3 VPW_3 VPW_0 WL[0] WL[1] sram464x144CCHD4
XMEM_R_COL_20 BL[0]_20 BL[1]_20 BL[2]_20 BL[3]_20 CORED00 CORED01 CORED10
+  CORED11 CORED20 CORED21 CORED30 CORED31 NBL[0]_20 NBL[1]_20 NBL[2]_20
+  NBL[3]_20 NCORED00 NCORED01 NCORED10 NCORED11 NCORED20 NCORED21 NCORED30
+  NCORED31 VDDC_20 VDDCE_20 VDDPE_20 VNWC_21 VPW_21 VPW_0 WL[0] WL[1]
+  sram464x144CCHD4
XMEM_R_COL_21 BL[0]_21 BL[1]_21 BL[2]_21 BL[3]_21 CORED00_16 CORED01_18
+  CORED10_20 CORED11_22 CORED20_24 CORED21_26 CORED30_28 CORED31_30 NBL[0]_21
+  NBL[1]_21 NBL[2]_21 NBL[3]_21 NCORED00_32 NCORED01_34 NCORED10_36
+  NCORED11_38 NCORED20_40 NCORED21_42 NCORED30_44 NCORED31_46 VDDC_21
+  VDDCE_21 VDDPE_21 VNWC_22 VPW_22 VPW_0 WL[0] WL[1] sram464x144CCHD4
XMEM_R_COL_22 BL[0]_22 BL[1]_22 BL[2]_22 BL[3]_22 CORED00_48 CORED01_50
+  CORED10_52 CORED11_54 CORED20_56 CORED21_58 CORED30_60 CORED31_62 NBL[0]_22
+  NBL[1]_22 NBL[2]_22 NBL[3]_22 NCORED00_64 NCORED01_66 NCORED10_68
+  NCORED11_70 NCORED20_72 NCORED21_74 NCORED30_76 NCORED31_78 VDDC_22
+  VDDCE_22 VDDPE_22 VNWC_23 VPW_23 VPW_0 WL[0] WL[1] sram464x144CCHD4
XMEM_R_COL_23 BL[0]_23 BL[1]_23 BL[2]_23 BL[3]_23 CORED00_80 CORED01_82
+  CORED10_84 CORED11_86 CORED20_88 CORED21_90 CORED30_92 CORED31_94 NBL[0]_23
+  NBL[1]_23 NBL[2]_23 NBL[3]_23 NCORED00_96 NCORED01_98 NCORED10_100
+  NCORED11_102 NCORED20_104 NCORED21_106 NCORED30_108 NCORED31_110 VDDC_23
+  VDDCE_23 VDDPE_23 VNWC_24 VPW_24 VPW_0 WL[0] WL[1] sram464x144CCHD4
XMEM_R_COL_24 BL[0]_24 BL[1]_24 BL[2]_24 BL[3]_24 CORED00_112 CORED01_114
+  CORED10_116 CORED11_118 CORED20_120 CORED21_122 CORED30_124 CORED31_126
+  NBL[0]_24 NBL[1]_24 NBL[2]_24 NBL[3]_24 NCORED00_128 NCORED01_130
+  NCORED10_132 NCORED11_134 NCORED20_136 NCORED21_138 NCORED30_140
+  NCORED31_142 VDDC_24 VDDCE_24 VDDPE_24 VNWC_25 VPW_25 VPW_0 WL[0] WL[1]
+  sram464x144CCHD4
XMEM_R_COL_25 BL[0]_25 BL[1]_25 BL[2]_25 BL[3]_25 CORED00_144 CORED01_146
+  CORED10_148 CORED11_150 CORED20_152 CORED21_154 CORED30_156 CORED31_158
+  NBL[0]_25 NBL[1]_25 NBL[2]_25 NBL[3]_25 NCORED00_160 NCORED01_162
+  NCORED10_164 NCORED11_166 NCORED20_168 NCORED21_170 NCORED30_172
+  NCORED31_174 VDDC_25 VDDCE_25 VDDPE_25 VNWC_26 VPW_26 VPW_0 WL[0] WL[1]
+  sram464x144CCHD4
XMEM_R_COL_26 BL[0]_26 BL[1]_26 BL[2]_26 BL[3]_26 CORED00_176 CORED01_178
+  CORED10_180 CORED11_182 CORED20_184 CORED21_186 CORED30_188 CORED31_190
+  NBL[0]_26 NBL[1]_26 NBL[2]_26 NBL[3]_26 NCORED00_192 NCORED01_194
+  NCORED10_196 NCORED11_198 NCORED20_200 NCORED21_202 NCORED30_204
+  NCORED31_206 VDDC_26 VDDCE_26 VDDPE_26 VNWC_27 VPW_27 VPW_0 WL[0] WL[1]
+  sram464x144CCHD4
XMEM_R_COL_27 BL[0]_27 BL[1]_27 BL[2]_27 BL[3]_27 CORED00_208 CORED01_210
+  CORED10_212 CORED11_214 CORED20_216 CORED21_218 CORED30_220 CORED31_222
+  NBL[0]_27 NBL[1]_27 NBL[2]_27 NBL[3]_27 NCORED00_224 NCORED01_226
+  NCORED10_228 NCORED11_230 NCORED20_232 NCORED21_234 NCORED30_236
+  NCORED31_238 VDDC_27 VDDCE_27 VDDPE_27 VNWC_28 VPW_28 VPW_0 WL[0] WL[1]
+  sram464x144CCHD4
XMEM_R_COL_28 BL[0]_28 BL[1]_28 BL[2]_28 BL[3]_28 CORED00_240 CORED01_242
+  CORED10_244 CORED11_246 CORED20_248 CORED21_250 CORED30_252 CORED31_254
+  NBL[0]_28 NBL[1]_28 NBL[2]_28 NBL[3]_28 NCORED00_256 NCORED01_258
+  NCORED10_260 NCORED11_262 NCORED20_264 NCORED21_266 NCORED30_268
+  NCORED31_270 VDDC_28 VDDCE_28 VDDPE_28 VNWC_29 VPW_29 VPW_0 WL[0] WL[1]
+  sram464x144CCHD4
XMEM_R_COL_29 BL[0]_29 BL[1]_29 BL[2]_29 BL[3]_29 CORED00_272 CORED01_274
+  CORED10_276 CORED11_278 CORED20_280 CORED21_282 CORED30_284 CORED31_286
+  NBL[0]_29 NBL[1]_29 NBL[2]_29 NBL[3]_29 NCORED00_288 NCORED01_290
+  NCORED10_292 NCORED11_294 NCORED20_296 NCORED21_298 NCORED30_300
+  NCORED31_302 VDDC_29 VDDCE_29 VDDPE_29 VNWC_30 VPW_30 VPW_0 WL[0] WL[1]
+  sram464x144CCHD4
XMEM_R_COL_3 BL[0]_3 BL[1]_3 BL[2]_3 BL[3]_3 CORED00_400 CORED01_402
+  CORED10_404 CORED11_406 CORED20_408 CORED21_410 CORED30_412 CORED31_414
+  NBL[0]_3 NBL[1]_3 NBL[2]_3 NBL[3]_3 NCORED00_416 NCORED01_418 NCORED10_420
+  NCORED11_422 NCORED20_424 NCORED21_426 NCORED30_428 NCORED31_430 VDDC_3
+  VDDCE_3 VDDPE_3 VNWC_4 VPW_4 VPW_0 WL[0] WL[1] sram464x144CCHD4
XMEM_R_COL_30 BL[0]_30 BL[1]_30 BL[2]_30 BL[3]_30 CORED00_720 CORED01_722
+  CORED10_724 CORED11_726 CORED20_728 CORED21_730 CORED30_732 CORED31_734
+  NBL[0]_30 NBL[1]_30 NBL[2]_30 NBL[3]_30 NCORED00_736 NCORED01_738
+  NCORED10_740 NCORED11_742 NCORED20_744 NCORED21_746 NCORED30_748
+  NCORED31_750 VDDC_30 VDDCE_30 VDDPE_30 VNWC_31 VPW_31 VPW_0 WL[0] WL[1]
+  sram464x144CCHD4
XMEM_R_COL_31 BL[0]_31 BL[1]_31 BL[2]_31 BL[3]_31 CORED00_752 CORED01_754
+  CORED10_756 CORED11_758 CORED20_760 CORED21_762 CORED30_764 CORED31_766
+  NBL[0]_31 NBL[1]_31 NBL[2]_31 NBL[3]_31 NCORED00_768 NCORED01_770
+  NCORED10_772 NCORED11_774 NCORED20_776 NCORED21_778 NCORED30_780
+  NCORED31_782 VDDC_31 VDDCE_31 VDDPE_31 VNWC_32 VPW_32 VPW_0 WL[0] WL[1]
+  sram464x144CCHD4
XMEM_R_COL_32 BL[0]_32 BL[1]_32 BL[2]_32 BL[3]_32 CORED00_816 CORED01_818
+  CORED10_820 CORED11_822 CORED20_824 CORED21_826 CORED30_828 CORED31_830
+  NBL[0]_32 NBL[1]_32 NBL[2]_32 NBL[3]_32 NCORED00_832 NCORED01_834
+  NCORED10_836 NCORED11_838 NCORED20_840 NCORED21_842 NCORED30_844
+  NCORED31_846 VDDC_32 VDDCE_32 VDDPE_32 VNWC_33 VPW_33 VPW_0 WL[0] WL[1]
+  sram464x144CCHD4
XMEM_R_COL_33 BL[0]_33 BL[1]_33 BL[2]_33 BL[3]_33 CORED00_880 CORED01_882
+  CORED10_884 CORED11_886 CORED20_888 CORED21_890 CORED30_892 CORED31_894
+  NBL[0]_33 NBL[1]_33 NBL[2]_33 NBL[3]_33 NCORED00_896 NCORED01_898
+  NCORED10_900 NCORED11_902 NCORED20_904 NCORED21_906 NCORED30_908
+  NCORED31_910 VDDC_33 VDDCE_33 VDDPE_33 VNWC_34 VPW_34 VPW_0 WL[0] WL[1]
+  sram464x144CCHD4
XMEM_R_COL_34 BL[0]_34 BL[1]_34 BL[2]_34 BL[3]_34 CORED00_944 CORED01_946
+  CORED10_948 CORED11_950 CORED20_952 CORED21_954 CORED30_956 CORED31_958
+  NBL[0]_34 NBL[1]_34 NBL[2]_34 NBL[3]_34 NCORED00_960 NCORED01_962
+  NCORED10_964 NCORED11_966 NCORED20_968 NCORED21_970 NCORED30_972
+  NCORED31_974 VDDC_34 VDDCE_34 VDDPE_34 VNWC_35 VPW_35 VPW_0 WL[0] WL[1]
+  sram464x144CCHD4
XMEM_R_COL_35 BL[0]_35 BL[1]_35 BL[2]_35 BL[3]_35 CORED00_1008 CORED01_1010
+  CORED10_1012 CORED11_1014 CORED20_1016 CORED21_1018 CORED30_1020
+  CORED31_1022 NBL[0]_35 NBL[1]_35 NBL[2]_35 NBL[3]_35 NCORED00_1024
+  NCORED01_1026 NCORED10_1028 NCORED11_1030 NCORED20_1032 NCORED21_1034
+  NCORED30_1036 NCORED31_1038 VDDC_35 VDDCE_35 VDDPE_35 VNWC_36 VPW_36 VPW_0
+  WL[0] WL[1] sram464x144CCHD4
XMEM_R_COL_4 BL[0]_4 BL[1]_4 BL[2]_4 BL[3]_4 CORED00_432 CORED01_434
+  CORED10_436 CORED11_438 CORED20_440 CORED21_442 CORED30_444 CORED31_446
+  NBL[0]_4 NBL[1]_4 NBL[2]_4 NBL[3]_4 NCORED00_448 NCORED01_450 NCORED10_452
+  NCORED11_454 NCORED20_456 NCORED21_458 NCORED30_460 NCORED31_462 VDDC_4
+  VDDCE_4 VDDPE_4 VNWC_5 VPW_5 VPW_0 WL[0] WL[1] sram464x144CCHD4
XMEM_R_COL_5 BL[0]_5 BL[1]_5 BL[2]_5 BL[3]_5 CORED00_464 CORED01_466
+  CORED10_468 CORED11_470 CORED20_472 CORED21_474 CORED30_476 CORED31_478
+  NBL[0]_5 NBL[1]_5 NBL[2]_5 NBL[3]_5 NCORED00_480 NCORED01_482 NCORED10_484
+  NCORED11_486 NCORED20_488 NCORED21_490 NCORED30_492 NCORED31_494 VDDC_5
+  VDDCE_5 VDDPE_5 VNWC_6 VPW_6 VPW_0 WL[0] WL[1] sram464x144CCHD4
XMEM_R_COL_6 BL[0]_6 BL[1]_6 BL[2]_6 BL[3]_6 CORED00_496 CORED01_498
+  CORED10_500 CORED11_502 CORED20_504 CORED21_506 CORED30_508 CORED31_510
+  NBL[0]_6 NBL[1]_6 NBL[2]_6 NBL[3]_6 NCORED00_512 NCORED01_514 NCORED10_516
+  NCORED11_518 NCORED20_520 NCORED21_522 NCORED30_524 NCORED31_526 VDDC_6
+  VDDCE_6 VDDPE_6 VNWC_7 VPW_7 VPW_0 WL[0] WL[1] sram464x144CCHD4
XMEM_R_COL_7 BL[0]_7 BL[1]_7 BL[2]_7 BL[3]_7 CORED00_528 CORED01_530
+  CORED10_532 CORED11_534 CORED20_536 CORED21_538 CORED30_540 CORED31_542
+  NBL[0]_7 NBL[1]_7 NBL[2]_7 NBL[3]_7 NCORED00_544 NCORED01_546 NCORED10_548
+  NCORED11_550 NCORED20_552 NCORED21_554 NCORED30_556 NCORED31_558 VDDC_7
+  VDDCE_7 VDDPE_7 VNWC_8 VPW_8 VPW_0 WL[0] WL[1] sram464x144CCHD4
XMEM_R_COL_8 BL[0]_8 BL[1]_8 BL[2]_8 BL[3]_8 CORED00_560 CORED01_562
+  CORED10_564 CORED11_566 CORED20_568 CORED21_570 CORED30_572 CORED31_574
+  NBL[0]_8 NBL[1]_8 NBL[2]_8 NBL[3]_8 NCORED00_576 NCORED01_578 NCORED10_580
+  NCORED11_582 NCORED20_584 NCORED21_586 NCORED30_588 NCORED31_590 VDDC_8
+  VDDCE_8 VDDPE_8 VNWC_9 VPW_9 VPW_0 WL[0] WL[1] sram464x144CCHD4
XMEM_R_COL_9 BL[0]_9 BL[1]_9 BL[2]_9 BL[3]_9 CORED00_592 CORED01_594
+  CORED10_596 CORED11_598 CORED20_600 CORED21_602 CORED30_604 CORED31_606
+  NBL[0]_9 NBL[1]_9 NBL[2]_9 NBL[3]_9 NCORED00_608 NCORED01_610 NCORED10_612
+  NCORED11_614 NCORED20_616 NCORED21_618 NCORED30_620 NCORED31_622 VDDC_9
+  VDDCE_9 VDDPE_9 VNWC_10 VPW_10 VPW_0 WL[0] WL[1] sram464x144CCHD4
XMEM_R_COL_EDGEL VNWC_0 VNWP_0 VPW_0 VPW_0 WL[0] WL[1] sram464x144CCHD4WD_EDG
XMEM_R_COL_EDGER VNWC_37 VNWP_1 VPW_0 VPW_0 WL[0] WL[1] sram464x144CCHD4_EDG
.ENDS sram464x144MEM_R_MIDT_ROW
****
.SUBCKT sram464x144MEM_SLICE_CAP_R BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4
+  BL[0]_5 BL[0]_6 BL[0]_7 BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13
+  BL[0]_14 BL[0]_15 BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21
+  BL[0]_22 BL[0]_23 BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29
+  BL[0]_30 BL[0]_31 BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1
+  BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10
+  BL[1]_11 BL[1]_12 BL[1]_13 BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18
+  BL[1]_19 BL[1]_20 BL[1]_21 BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26
+  BL[1]_27 BL[1]_28 BL[1]_29 BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34
+  BL[1]_35 BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7
+  BL[2]_8 BL[2]_9 BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15
+  BL[2]_16 BL[2]_17 BL[2]_18 BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23
+  BL[2]_24 BL[2]_25 BL[2]_26 BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31
+  BL[2]_32 BL[2]_33 BL[2]_34 BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4
+  BL[3]_5 BL[3]_6 BL[3]_7 BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13
+  BL[3]_14 BL[3]_15 BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21
+  BL[3]_22 BL[3]_23 BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29
+  BL[3]_30 BL[3]_31 BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1
+  NBL[0]_2 NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9
+  NBL[0]_10 NBL[0]_11 NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16
+  NBL[0]_17 NBL[0]_18 NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23
+  NBL[0]_24 NBL[0]_25 NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30
+  NBL[0]_31 NBL[0]_32 NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1
+  NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9
+  NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16
+  NBL[1]_17 NBL[1]_18 NBL[1]_19 NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23
+  NBL[1]_24 NBL[1]_25 NBL[1]_26 NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30
+  NBL[1]_31 NBL[1]_32 NBL[1]_33 NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1
+  NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9
+  NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13 NBL[2]_14 NBL[2]_15 NBL[2]_16
+  NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20 NBL[2]_21 NBL[2]_22 NBL[2]_23
+  NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27 NBL[2]_28 NBL[2]_29 NBL[2]_30
+  NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34 NBL[2]_35 NBL[3]_0 NBL[3]_1
+  NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 NBL[3]_8 NBL[3]_9
+  NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13 NBL[3]_14 NBL[3]_15 NBL[3]_16
+  NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20 NBL[3]_21 NBL[3]_22 NBL[3]_23
+  NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27 NBL[3]_28 NBL[3]_29 NBL[3]_30
+  NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34 NBL[3]_35 VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8 VDDPE_9 VDDPE_10 VDDPE_11
+  VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16 VDDPE_17 VDDPE_18 VDDPE_19
+  VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24 VDDPE_25 VDDPE_26 VDDPE_27
+  VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32 VDDPE_33 VDDPE_34 VDDPE_35
+  VNWC VNWP_0 VNWP_1 VPW
** sram464x144MEM_SLICE_CAP_R: 1158 flat devices **
XTOP_EDGE_ROW0 BL[0]_0 BL[1]_0 BL[2]_0 BL[3]_0 NBL[0]_0 NBL[1]_0 NBL[2]_0
+  NBL[3]_0 VNWC VNWC VDDPE_0 VNWC VPW VPW sram464x144CCHD4_TOPBOT
XTOP_EDGE_ROW1 BL[0]_1 BL[1]_1 BL[2]_1 BL[3]_1 NBL[0]_1 NBL[1]_1 NBL[2]_1
+  NBL[3]_1 VNWC VNWC VDDPE_1 VNWC VPW VPW sram464x144CCHD4_TOPBOT
XTOP_EDGE_ROW10 BL[0]_10 BL[1]_10 BL[2]_10 BL[3]_10 NBL[0]_10 NBL[1]_10
+  NBL[2]_10 NBL[3]_10 VNWC VNWC VDDPE_10 VNWC VPW VPW sram464x144CCHD4_TOPBOT
XTOP_EDGE_ROW11 BL[0]_11 BL[1]_11 BL[2]_11 BL[3]_11 NBL[0]_11 NBL[1]_11
+  NBL[2]_11 NBL[3]_11 VNWC VNWC VDDPE_11 VNWC VPW VPW sram464x144CCHD4_TOPBOT
XTOP_EDGE_ROW12 BL[0]_12 BL[1]_12 BL[2]_12 BL[3]_12 NBL[0]_12 NBL[1]_12
+  NBL[2]_12 NBL[3]_12 VNWC VNWC VDDPE_12 VNWC VPW VPW sram464x144CCHD4_TOPBOT
XTOP_EDGE_ROW13 BL[0]_13 BL[1]_13 BL[2]_13 BL[3]_13 NBL[0]_13 NBL[1]_13
+  NBL[2]_13 NBL[3]_13 VNWC VNWC VDDPE_13 VNWC VPW VPW sram464x144CCHD4_TOPBOT
XTOP_EDGE_ROW14 BL[0]_14 BL[1]_14 BL[2]_14 BL[3]_14 NBL[0]_14 NBL[1]_14
+  NBL[2]_14 NBL[3]_14 VNWC VNWC VDDPE_14 VNWC VPW VPW sram464x144CCHD4_TOPBOT
XTOP_EDGE_ROW15 BL[0]_15 BL[1]_15 BL[2]_15 BL[3]_15 NBL[0]_15 NBL[1]_15
+  NBL[2]_15 NBL[3]_15 VNWC VNWC VDDPE_15 VNWC VPW VPW sram464x144CCHD4_TOPBOT
XTOP_EDGE_ROW16 BL[0]_16 BL[1]_16 BL[2]_16 BL[3]_16 NBL[0]_16 NBL[1]_16
+  NBL[2]_16 NBL[3]_16 VNWC VNWC VDDPE_16 VNWC VPW VPW sram464x144CCHD4_TOPBOT
XTOP_EDGE_ROW17 BL[0]_17 BL[1]_17 BL[2]_17 BL[3]_17 NBL[0]_17 NBL[1]_17
+  NBL[2]_17 NBL[3]_17 VNWC VNWC VDDPE_17 VNWC VPW VPW sram464x144CCHD4_TOPBOT
XTOP_EDGE_ROW18 BL[0]_18 BL[1]_18 BL[2]_18 BL[3]_18 NBL[0]_18 NBL[1]_18
+  NBL[2]_18 NBL[3]_18 VNWC VNWC VDDPE_18 VNWC VPW VPW sram464x144CCHD4_TOPBOT
XTOP_EDGE_ROW19 BL[0]_19 BL[1]_19 BL[2]_19 BL[3]_19 NBL[0]_19 NBL[1]_19
+  NBL[2]_19 NBL[3]_19 VNWC VNWC VDDPE_19 VNWC VPW VPW sram464x144CCHD4_TOPBOT
XTOP_EDGE_ROW2 BL[0]_2 BL[1]_2 BL[2]_2 BL[3]_2 NBL[0]_2 NBL[1]_2 NBL[2]_2
+  NBL[3]_2 VNWC VNWC VDDPE_2 VNWC VPW VPW sram464x144CCHD4_TOPBOT
XTOP_EDGE_ROW20 BL[0]_20 BL[1]_20 BL[2]_20 BL[3]_20 NBL[0]_20 NBL[1]_20
+  NBL[2]_20 NBL[3]_20 VNWC VNWC VDDPE_20 VNWC VPW VPW sram464x144CCHD4_TOPBOT
XTOP_EDGE_ROW21 BL[0]_21 BL[1]_21 BL[2]_21 BL[3]_21 NBL[0]_21 NBL[1]_21
+  NBL[2]_21 NBL[3]_21 VNWC VNWC VDDPE_21 VNWC VPW VPW sram464x144CCHD4_TOPBOT
XTOP_EDGE_ROW22 BL[0]_22 BL[1]_22 BL[2]_22 BL[3]_22 NBL[0]_22 NBL[1]_22
+  NBL[2]_22 NBL[3]_22 VNWC VNWC VDDPE_22 VNWC VPW VPW sram464x144CCHD4_TOPBOT
XTOP_EDGE_ROW23 BL[0]_23 BL[1]_23 BL[2]_23 BL[3]_23 NBL[0]_23 NBL[1]_23
+  NBL[2]_23 NBL[3]_23 VNWC VNWC VDDPE_23 VNWC VPW VPW sram464x144CCHD4_TOPBOT
XTOP_EDGE_ROW24 BL[0]_24 BL[1]_24 BL[2]_24 BL[3]_24 NBL[0]_24 NBL[1]_24
+  NBL[2]_24 NBL[3]_24 VNWC VNWC VDDPE_24 VNWC VPW VPW sram464x144CCHD4_TOPBOT
XTOP_EDGE_ROW25 BL[0]_25 BL[1]_25 BL[2]_25 BL[3]_25 NBL[0]_25 NBL[1]_25
+  NBL[2]_25 NBL[3]_25 VNWC VNWC VDDPE_25 VNWC VPW VPW sram464x144CCHD4_TOPBOT
XTOP_EDGE_ROW26 BL[0]_26 BL[1]_26 BL[2]_26 BL[3]_26 NBL[0]_26 NBL[1]_26
+  NBL[2]_26 NBL[3]_26 VNWC VNWC VDDPE_26 VNWC VPW VPW sram464x144CCHD4_TOPBOT
XTOP_EDGE_ROW27 BL[0]_27 BL[1]_27 BL[2]_27 BL[3]_27 NBL[0]_27 NBL[1]_27
+  NBL[2]_27 NBL[3]_27 VNWC VNWC VDDPE_27 VNWC VPW VPW sram464x144CCHD4_TOPBOT
XTOP_EDGE_ROW28 BL[0]_28 BL[1]_28 BL[2]_28 BL[3]_28 NBL[0]_28 NBL[1]_28
+  NBL[2]_28 NBL[3]_28 VNWC VNWC VDDPE_28 VNWC VPW VPW sram464x144CCHD4_TOPBOT
XTOP_EDGE_ROW29 BL[0]_29 BL[1]_29 BL[2]_29 BL[3]_29 NBL[0]_29 NBL[1]_29
+  NBL[2]_29 NBL[3]_29 VNWC VNWC VDDPE_29 VNWC VPW VPW sram464x144CCHD4_TOPBOT
XTOP_EDGE_ROW3 BL[0]_3 BL[1]_3 BL[2]_3 BL[3]_3 NBL[0]_3 NBL[1]_3 NBL[2]_3
+  NBL[3]_3 VNWC VNWC VDDPE_3 VNWC VPW VPW sram464x144CCHD4_TOPBOT
XTOP_EDGE_ROW30 BL[0]_30 BL[1]_30 BL[2]_30 BL[3]_30 NBL[0]_30 NBL[1]_30
+  NBL[2]_30 NBL[3]_30 VNWC VNWC VDDPE_30 VNWC VPW VPW sram464x144CCHD4_TOPBOT
XTOP_EDGE_ROW31 BL[0]_31 BL[1]_31 BL[2]_31 BL[3]_31 NBL[0]_31 NBL[1]_31
+  NBL[2]_31 NBL[3]_31 VNWC VNWC VDDPE_31 VNWC VPW VPW sram464x144CCHD4_TOPBOT
XTOP_EDGE_ROW32 BL[0]_32 BL[1]_32 BL[2]_32 BL[3]_32 NBL[0]_32 NBL[1]_32
+  NBL[2]_32 NBL[3]_32 VNWC VNWC VDDPE_32 VNWC VPW VPW sram464x144CCHD4_TOPBOT
XTOP_EDGE_ROW33 BL[0]_33 BL[1]_33 BL[2]_33 BL[3]_33 NBL[0]_33 NBL[1]_33
+  NBL[2]_33 NBL[3]_33 VNWC VNWC VDDPE_33 VNWC VPW VPW sram464x144CCHD4_TOPBOT
XTOP_EDGE_ROW34 BL[0]_34 BL[1]_34 BL[2]_34 BL[3]_34 NBL[0]_34 NBL[1]_34
+  NBL[2]_34 NBL[3]_34 VNWC VNWC VDDPE_34 VNWC VPW VPW sram464x144CCHD4_TOPBOT
XTOP_EDGE_ROW35 BL[0]_35 BL[1]_35 BL[2]_35 BL[3]_35 NBL[0]_35 NBL[1]_35
+  NBL[2]_35 NBL[3]_35 VNWC VNWC VDDPE_35 VNWC VPW VPW sram464x144CCHD4_TOPBOT
XTOP_EDGE_ROW4 BL[0]_4 BL[1]_4 BL[2]_4 BL[3]_4 NBL[0]_4 NBL[1]_4 NBL[2]_4
+  NBL[3]_4 VNWC VNWC VDDPE_4 VNWC VPW VPW sram464x144CCHD4_TOPBOT
XTOP_EDGE_ROW5 BL[0]_5 BL[1]_5 BL[2]_5 BL[3]_5 NBL[0]_5 NBL[1]_5 NBL[2]_5
+  NBL[3]_5 VNWC VNWC VDDPE_5 VNWC VPW VPW sram464x144CCHD4_TOPBOT
XTOP_EDGE_ROW6 BL[0]_6 BL[1]_6 BL[2]_6 BL[3]_6 NBL[0]_6 NBL[1]_6 NBL[2]_6
+  NBL[3]_6 VNWC VNWC VDDPE_6 VNWC VPW VPW sram464x144CCHD4_TOPBOT
XTOP_EDGE_ROW7 BL[0]_7 BL[1]_7 BL[2]_7 BL[3]_7 NBL[0]_7 NBL[1]_7 NBL[2]_7
+  NBL[3]_7 VNWC VNWC VDDPE_7 VNWC VPW VPW sram464x144CCHD4_TOPBOT
XTOP_EDGE_ROW8 BL[0]_8 BL[1]_8 BL[2]_8 BL[3]_8 NBL[0]_8 NBL[1]_8 NBL[2]_8
+  NBL[3]_8 VNWC VNWC VDDPE_8 VNWC VPW VPW sram464x144CCHD4_TOPBOT
XTOP_EDGE_ROW9 BL[0]_9 BL[1]_9 BL[2]_9 BL[3]_9 NBL[0]_9 NBL[1]_9 NBL[2]_9
+  NBL[3]_9 VNWC VNWC VDDPE_9 VNWC VPW VPW sram464x144CCHD4_TOPBOT
XTOP_EDGE_ROWEDGEL VNWC VNWC VNWP_0 VPW VPW sram464x144CCHD4WD_CORNER
XTOP_EDGE_ROWEDGER VNWC VNWC VNWP_1 VPW VPW sram464x144CCHD4_CORNER
.ENDS sram464x144MEM_SLICE_CAP_R
****
.SUBCKT sram464x144MEM_R_MID_ROW BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4
+  BL[0]_5 BL[0]_6 BL[0]_7 BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13
+  BL[0]_14 BL[0]_15 BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21
+  BL[0]_22 BL[0]_23 BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29
+  BL[0]_30 BL[0]_31 BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1
+  BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10
+  BL[1]_11 BL[1]_12 BL[1]_13 BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18
+  BL[1]_19 BL[1]_20 BL[1]_21 BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26
+  BL[1]_27 BL[1]_28 BL[1]_29 BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34
+  BL[1]_35 BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7
+  BL[2]_8 BL[2]_9 BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15
+  BL[2]_16 BL[2]_17 BL[2]_18 BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23
+  BL[2]_24 BL[2]_25 BL[2]_26 BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31
+  BL[2]_32 BL[2]_33 BL[2]_34 BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4
+  BL[3]_5 BL[3]_6 BL[3]_7 BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13
+  BL[3]_14 BL[3]_15 BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21
+  BL[3]_22 BL[3]_23 BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29
+  BL[3]_30 BL[3]_31 BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1
+  NBL[0]_2 NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9
+  NBL[0]_10 NBL[0]_11 NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16
+  NBL[0]_17 NBL[0]_18 NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23
+  NBL[0]_24 NBL[0]_25 NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30
+  NBL[0]_31 NBL[0]_32 NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1
+  NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9
+  NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16
+  NBL[1]_17 NBL[1]_18 NBL[1]_19 NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23
+  NBL[1]_24 NBL[1]_25 NBL[1]_26 NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30
+  NBL[1]_31 NBL[1]_32 NBL[1]_33 NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1
+  NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9
+  NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13 NBL[2]_14 NBL[2]_15 NBL[2]_16
+  NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20 NBL[2]_21 NBL[2]_22 NBL[2]_23
+  NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27 NBL[2]_28 NBL[2]_29 NBL[2]_30
+  NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34 NBL[2]_35 NBL[3]_0 NBL[3]_1
+  NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 NBL[3]_8 NBL[3]_9
+  NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13 NBL[3]_14 NBL[3]_15 NBL[3]_16
+  NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20 NBL[3]_21 NBL[3]_22 NBL[3]_23
+  NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27 NBL[3]_28 NBL[3]_29 NBL[3]_30
+  NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34 NBL[3]_35 VDDCE_0 VDDCE_1 VDDCE_2
+  VDDCE_3 VDDCE_4 VDDCE_5 VDDCE_6 VDDCE_7 VDDCE_8 VDDCE_9 VDDCE_10 VDDCE_11
+  VDDCE_12 VDDCE_13 VDDCE_14 VDDCE_15 VDDCE_16 VDDCE_17 VDDCE_18 VDDCE_19
+  VDDCE_20 VDDCE_21 VDDCE_22 VDDCE_23 VDDCE_24 VDDCE_25 VDDCE_26 VDDCE_27
+  VDDCE_28 VDDCE_29 VDDCE_30 VDDCE_31 VDDCE_32 VDDCE_33 VDDCE_34 VDDCE_35
+  VDDC_0 VDDC_1 VDDC_2 VDDC_3 VDDC_4 VDDC_5 VDDC_6 VDDC_7 VDDC_8 VDDC_9
+  VDDC_10 VDDC_11 VDDC_12 VDDC_13 VDDC_14 VDDC_15 VDDC_16 VDDC_17 VDDC_18
+  VDDC_19 VDDC_20 VDDC_21 VDDC_22 VDDC_23 VDDC_24 VDDC_25 VDDC_26 VDDC_27
+  VDDC_28 VDDC_29 VDDC_30 VDDC_31 VDDC_32 VDDC_33 VDDC_34 VDDC_35 VDDPE_0
+  VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8 VDDPE_9
+  VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16 VDDPE_17
+  VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24 VDDPE_25
+  VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32 VDDPE_33
+  VDDPE_34 VDDPE_35 VNWC_0 VNWC_1 VNWC_2 VNWC_3 VNWC_4 VNWC_5 VNWC_6 VNWC_7
+  VNWC_8 VNWC_9 VNWC_10 VNWC_11 VNWC_12 VNWC_13 VNWC_14 VNWC_15 VNWC_16
+  VNWC_17 VNWC_18 VNWC_19 VNWC_20 VNWC_21 VNWC_22 VNWC_23 VNWC_24 VNWC_25
+  VNWC_26 VNWC_27 VNWC_28 VNWC_29 VNWC_30 VNWC_31 VNWC_32 VNWC_33 VNWC_34
+  VNWC_35 VNWC_36 VNWC_37 VNWP_0 VNWP_1 VPW_0 VPW_1 VPW_2 VPW_3 VPW_4 VPW_5
+  VPW_6 VPW_7 VPW_8 VPW_9 VPW_10 VPW_11 VPW_12 VPW_13 VPW_14 VPW_15 VPW_16
+  VPW_17 VPW_18 VPW_19 VPW_20 VPW_21 VPW_22 VPW_23 VPW_24 VPW_25 VPW_26
+  VPW_27 VPW_28 VPW_29 VPW_30 VPW_31 VPW_32 VPW_33 VPW_34 VPW_35 VPW_36 WL[0]
+  WL[1]
** sram464x144MEM_R_MID_ROW: 1732 flat devices **
XMEM_R_COL_0 BL[0]_0 BL[1]_0 BL[2]_0 BL[3]_0 CORED00_304 CORED01_306
+  CORED10_308 CORED11_310 CORED20_312 CORED21_314 CORED30_316 CORED31_318
+  NBL[0]_0 NBL[1]_0 NBL[2]_0 NBL[3]_0 NCORED00_320 NCORED01_322 NCORED10_324
+  NCORED11_326 NCORED20_328 NCORED21_330 NCORED30_332 NCORED31_334 VDDC_0
+  VDDCE_0 VDDPE_0 VNWC_1 VPW_1 VPW_0 WL[0] WL[1] sram464x144CCHD4
XMEM_R_COL_1 BL[0]_1 BL[1]_1 BL[2]_1 BL[3]_1 CORED00_336 CORED01_338
+  CORED10_340 CORED11_342 CORED20_344 CORED21_346 CORED30_348 CORED31_350
+  NBL[0]_1 NBL[1]_1 NBL[2]_1 NBL[3]_1 NCORED00_352 NCORED01_354 NCORED10_356
+  NCORED11_358 NCORED20_360 NCORED21_362 NCORED30_364 NCORED31_366 VDDC_1
+  VDDCE_1 VDDPE_1 VNWC_2 VPW_2 VPW_0 WL[0] WL[1] sram464x144CCHD4
XMEM_R_COL_10 BL[0]_10 BL[1]_10 BL[2]_10 BL[3]_10 CORED00_624 CORED01_626
+  CORED10_628 CORED11_630 CORED20_632 CORED21_634 CORED30_636 CORED31_638
+  NBL[0]_10 NBL[1]_10 NBL[2]_10 NBL[3]_10 NCORED00_640 NCORED01_642
+  NCORED10_644 NCORED11_646 NCORED20_648 NCORED21_650 NCORED30_652
+  NCORED31_654 VDDC_10 VDDCE_10 VDDPE_10 VNWC_11 VPW_11 VPW_0 WL[0] WL[1]
+  sram464x144CCHD4
XMEM_R_COL_11 BL[0]_11 BL[1]_11 BL[2]_11 BL[3]_11 CORED00_656 CORED01_658
+  CORED10_660 CORED11_662 CORED20_664 CORED21_666 CORED30_668 CORED31_670
+  NBL[0]_11 NBL[1]_11 NBL[2]_11 NBL[3]_11 NCORED00_672 NCORED01_674
+  NCORED10_676 NCORED11_678 NCORED20_680 NCORED21_682 NCORED30_684
+  NCORED31_686 VDDC_11 VDDCE_11 VDDPE_11 VNWC_12 VPW_12 VPW_0 WL[0] WL[1]
+  sram464x144CCHD4
XMEM_R_COL_12 BL[0]_12 BL[1]_12 BL[2]_12 BL[3]_12 CORED00_688 CORED01_690
+  CORED10_692 CORED11_694 CORED20_696 CORED21_698 CORED30_700 CORED31_702
+  NBL[0]_12 NBL[1]_12 NBL[2]_12 NBL[3]_12 NCORED00_704 NCORED01_706
+  NCORED10_708 NCORED11_710 NCORED20_712 NCORED21_714 NCORED30_716
+  NCORED31_718 VDDC_12 VDDCE_12 VDDPE_12 VNWC_13 VPW_13 VPW_0 WL[0] WL[1]
+  sram464x144CCHD4
XMEM_R_COL_13 BL[0]_13 BL[1]_13 BL[2]_13 BL[3]_13 CORED00_784 CORED01_786
+  CORED10_788 CORED11_790 CORED20_792 CORED21_794 CORED30_796 CORED31_798
+  NBL[0]_13 NBL[1]_13 NBL[2]_13 NBL[3]_13 NCORED00_800 NCORED01_802
+  NCORED10_804 NCORED11_806 NCORED20_808 NCORED21_810 NCORED30_812
+  NCORED31_814 VDDC_13 VDDCE_13 VDDPE_13 VNWC_14 VPW_14 VPW_0 WL[0] WL[1]
+  sram464x144CCHD4
XMEM_R_COL_14 BL[0]_14 BL[1]_14 BL[2]_14 BL[3]_14 CORED00_848 CORED01_850
+  CORED10_852 CORED11_854 CORED20_856 CORED21_858 CORED30_860 CORED31_862
+  NBL[0]_14 NBL[1]_14 NBL[2]_14 NBL[3]_14 NCORED00_864 NCORED01_866
+  NCORED10_868 NCORED11_870 NCORED20_872 NCORED21_874 NCORED30_876
+  NCORED31_878 VDDC_14 VDDCE_14 VDDPE_14 VNWC_15 VPW_15 VPW_0 WL[0] WL[1]
+  sram464x144CCHD4
XMEM_R_COL_15 BL[0]_15 BL[1]_15 BL[2]_15 BL[3]_15 CORED00_912 CORED01_914
+  CORED10_916 CORED11_918 CORED20_920 CORED21_922 CORED30_924 CORED31_926
+  NBL[0]_15 NBL[1]_15 NBL[2]_15 NBL[3]_15 NCORED00_928 NCORED01_930
+  NCORED10_932 NCORED11_934 NCORED20_936 NCORED21_938 NCORED30_940
+  NCORED31_942 VDDC_15 VDDCE_15 VDDPE_15 VNWC_16 VPW_16 VPW_0 WL[0] WL[1]
+  sram464x144CCHD4
XMEM_R_COL_16 BL[0]_16 BL[1]_16 BL[2]_16 BL[3]_16 CORED00_976 CORED01_978
+  CORED10_980 CORED11_982 CORED20_984 CORED21_986 CORED30_988 CORED31_990
+  NBL[0]_16 NBL[1]_16 NBL[2]_16 NBL[3]_16 NCORED00_992 NCORED01_994
+  NCORED10_996 NCORED11_998 NCORED20_1000 NCORED21_1002 NCORED30_1004
+  NCORED31_1006 VDDC_16 VDDCE_16 VDDPE_16 VNWC_17 VPW_17 VPW_0 WL[0] WL[1]
+  sram464x144CCHD4
XMEM_R_COL_17 BL[0]_17 BL[1]_17 BL[2]_17 BL[3]_17 CORED00_1040 CORED01_1042
+  CORED10_1044 CORED11_1046 CORED20_1048 CORED21_1050 CORED30_1052
+  CORED31_1054 NBL[0]_17 NBL[1]_17 NBL[2]_17 NBL[3]_17 NCORED00_1056
+  NCORED01_1058 NCORED10_1060 NCORED11_1062 NCORED20_1064 NCORED21_1066
+  NCORED30_1068 NCORED31_1070 VDDC_17 VDDCE_17 VDDPE_17 VNWC_18 VPW_18 VPW_0
+  WL[0] WL[1] sram464x144CCHD4
XMEM_R_COL_18 BL[0]_18 BL[1]_18 BL[2]_18 BL[3]_18 CORED00_1072 CORED01_1074
+  CORED10_1076 CORED11_1078 CORED20_1080 CORED21_1082 CORED30_1084
+  CORED31_1086 NBL[0]_18 NBL[1]_18 NBL[2]_18 NBL[3]_18 NCORED00_1088
+  NCORED01_1090 NCORED10_1092 NCORED11_1094 NCORED20_1096 NCORED21_1098
+  NCORED30_1100 NCORED31_1102 VDDC_18 VDDCE_18 VDDPE_18 VNWC_19 VPW_19 VPW_0
+  WL[0] WL[1] sram464x144CCHD4
XMEM_R_COL_19 BL[0]_19 BL[1]_19 BL[2]_19 BL[3]_19 CORED00_1104 CORED01_1106
+  CORED10_1108 CORED11_1110 CORED20_1112 CORED21_1114 CORED30_1116
+  CORED31_1118 NBL[0]_19 NBL[1]_19 NBL[2]_19 NBL[3]_19 NCORED00_1120
+  NCORED01_1122 NCORED10_1124 NCORED11_1126 NCORED20_1128 NCORED21_1130
+  NCORED30_1132 NCORED31_1134 VDDC_19 VDDCE_19 VDDPE_19 VNWC_20 VPW_20 VPW_0
+  WL[0] WL[1] sram464x144CCHD4
XMEM_R_COL_2 BL[0]_2 BL[1]_2 BL[2]_2 BL[3]_2 CORED00_368 CORED01_370
+  CORED10_372 CORED11_374 CORED20_376 CORED21_378 CORED30_380 CORED31_382
+  NBL[0]_2 NBL[1]_2 NBL[2]_2 NBL[3]_2 NCORED00_384 NCORED01_386 NCORED10_388
+  NCORED11_390 NCORED20_392 NCORED21_394 NCORED30_396 NCORED31_398 VDDC_2
+  VDDCE_2 VDDPE_2 VNWC_3 VPW_3 VPW_0 WL[0] WL[1] sram464x144CCHD4
XMEM_R_COL_20 BL[0]_20 BL[1]_20 BL[2]_20 BL[3]_20 CORED00 CORED01 CORED10
+  CORED11 CORED20 CORED21 CORED30 CORED31 NBL[0]_20 NBL[1]_20 NBL[2]_20
+  NBL[3]_20 NCORED00 NCORED01 NCORED10 NCORED11 NCORED20 NCORED21 NCORED30
+  NCORED31 VDDC_20 VDDCE_20 VDDPE_20 VNWC_21 VPW_21 VPW_0 WL[0] WL[1]
+  sram464x144CCHD4
XMEM_R_COL_21 BL[0]_21 BL[1]_21 BL[2]_21 BL[3]_21 CORED00_16 CORED01_18
+  CORED10_20 CORED11_22 CORED20_24 CORED21_26 CORED30_28 CORED31_30 NBL[0]_21
+  NBL[1]_21 NBL[2]_21 NBL[3]_21 NCORED00_32 NCORED01_34 NCORED10_36
+  NCORED11_38 NCORED20_40 NCORED21_42 NCORED30_44 NCORED31_46 VDDC_21
+  VDDCE_21 VDDPE_21 VNWC_22 VPW_22 VPW_0 WL[0] WL[1] sram464x144CCHD4
XMEM_R_COL_22 BL[0]_22 BL[1]_22 BL[2]_22 BL[3]_22 CORED00_48 CORED01_50
+  CORED10_52 CORED11_54 CORED20_56 CORED21_58 CORED30_60 CORED31_62 NBL[0]_22
+  NBL[1]_22 NBL[2]_22 NBL[3]_22 NCORED00_64 NCORED01_66 NCORED10_68
+  NCORED11_70 NCORED20_72 NCORED21_74 NCORED30_76 NCORED31_78 VDDC_22
+  VDDCE_22 VDDPE_22 VNWC_23 VPW_23 VPW_0 WL[0] WL[1] sram464x144CCHD4
XMEM_R_COL_23 BL[0]_23 BL[1]_23 BL[2]_23 BL[3]_23 CORED00_80 CORED01_82
+  CORED10_84 CORED11_86 CORED20_88 CORED21_90 CORED30_92 CORED31_94 NBL[0]_23
+  NBL[1]_23 NBL[2]_23 NBL[3]_23 NCORED00_96 NCORED01_98 NCORED10_100
+  NCORED11_102 NCORED20_104 NCORED21_106 NCORED30_108 NCORED31_110 VDDC_23
+  VDDCE_23 VDDPE_23 VNWC_24 VPW_24 VPW_0 WL[0] WL[1] sram464x144CCHD4
XMEM_R_COL_24 BL[0]_24 BL[1]_24 BL[2]_24 BL[3]_24 CORED00_112 CORED01_114
+  CORED10_116 CORED11_118 CORED20_120 CORED21_122 CORED30_124 CORED31_126
+  NBL[0]_24 NBL[1]_24 NBL[2]_24 NBL[3]_24 NCORED00_128 NCORED01_130
+  NCORED10_132 NCORED11_134 NCORED20_136 NCORED21_138 NCORED30_140
+  NCORED31_142 VDDC_24 VDDCE_24 VDDPE_24 VNWC_25 VPW_25 VPW_0 WL[0] WL[1]
+  sram464x144CCHD4
XMEM_R_COL_25 BL[0]_25 BL[1]_25 BL[2]_25 BL[3]_25 CORED00_144 CORED01_146
+  CORED10_148 CORED11_150 CORED20_152 CORED21_154 CORED30_156 CORED31_158
+  NBL[0]_25 NBL[1]_25 NBL[2]_25 NBL[3]_25 NCORED00_160 NCORED01_162
+  NCORED10_164 NCORED11_166 NCORED20_168 NCORED21_170 NCORED30_172
+  NCORED31_174 VDDC_25 VDDCE_25 VDDPE_25 VNWC_26 VPW_26 VPW_0 WL[0] WL[1]
+  sram464x144CCHD4
XMEM_R_COL_26 BL[0]_26 BL[1]_26 BL[2]_26 BL[3]_26 CORED00_176 CORED01_178
+  CORED10_180 CORED11_182 CORED20_184 CORED21_186 CORED30_188 CORED31_190
+  NBL[0]_26 NBL[1]_26 NBL[2]_26 NBL[3]_26 NCORED00_192 NCORED01_194
+  NCORED10_196 NCORED11_198 NCORED20_200 NCORED21_202 NCORED30_204
+  NCORED31_206 VDDC_26 VDDCE_26 VDDPE_26 VNWC_27 VPW_27 VPW_0 WL[0] WL[1]
+  sram464x144CCHD4
XMEM_R_COL_27 BL[0]_27 BL[1]_27 BL[2]_27 BL[3]_27 CORED00_208 CORED01_210
+  CORED10_212 CORED11_214 CORED20_216 CORED21_218 CORED30_220 CORED31_222
+  NBL[0]_27 NBL[1]_27 NBL[2]_27 NBL[3]_27 NCORED00_224 NCORED01_226
+  NCORED10_228 NCORED11_230 NCORED20_232 NCORED21_234 NCORED30_236
+  NCORED31_238 VDDC_27 VDDCE_27 VDDPE_27 VNWC_28 VPW_28 VPW_0 WL[0] WL[1]
+  sram464x144CCHD4
XMEM_R_COL_28 BL[0]_28 BL[1]_28 BL[2]_28 BL[3]_28 CORED00_240 CORED01_242
+  CORED10_244 CORED11_246 CORED20_248 CORED21_250 CORED30_252 CORED31_254
+  NBL[0]_28 NBL[1]_28 NBL[2]_28 NBL[3]_28 NCORED00_256 NCORED01_258
+  NCORED10_260 NCORED11_262 NCORED20_264 NCORED21_266 NCORED30_268
+  NCORED31_270 VDDC_28 VDDCE_28 VDDPE_28 VNWC_29 VPW_29 VPW_0 WL[0] WL[1]
+  sram464x144CCHD4
XMEM_R_COL_29 BL[0]_29 BL[1]_29 BL[2]_29 BL[3]_29 CORED00_272 CORED01_274
+  CORED10_276 CORED11_278 CORED20_280 CORED21_282 CORED30_284 CORED31_286
+  NBL[0]_29 NBL[1]_29 NBL[2]_29 NBL[3]_29 NCORED00_288 NCORED01_290
+  NCORED10_292 NCORED11_294 NCORED20_296 NCORED21_298 NCORED30_300
+  NCORED31_302 VDDC_29 VDDCE_29 VDDPE_29 VNWC_30 VPW_30 VPW_0 WL[0] WL[1]
+  sram464x144CCHD4
XMEM_R_COL_3 BL[0]_3 BL[1]_3 BL[2]_3 BL[3]_3 CORED00_400 CORED01_402
+  CORED10_404 CORED11_406 CORED20_408 CORED21_410 CORED30_412 CORED31_414
+  NBL[0]_3 NBL[1]_3 NBL[2]_3 NBL[3]_3 NCORED00_416 NCORED01_418 NCORED10_420
+  NCORED11_422 NCORED20_424 NCORED21_426 NCORED30_428 NCORED31_430 VDDC_3
+  VDDCE_3 VDDPE_3 VNWC_4 VPW_4 VPW_0 WL[0] WL[1] sram464x144CCHD4
XMEM_R_COL_30 BL[0]_30 BL[1]_30 BL[2]_30 BL[3]_30 CORED00_720 CORED01_722
+  CORED10_724 CORED11_726 CORED20_728 CORED21_730 CORED30_732 CORED31_734
+  NBL[0]_30 NBL[1]_30 NBL[2]_30 NBL[3]_30 NCORED00_736 NCORED01_738
+  NCORED10_740 NCORED11_742 NCORED20_744 NCORED21_746 NCORED30_748
+  NCORED31_750 VDDC_30 VDDCE_30 VDDPE_30 VNWC_31 VPW_31 VPW_0 WL[0] WL[1]
+  sram464x144CCHD4
XMEM_R_COL_31 BL[0]_31 BL[1]_31 BL[2]_31 BL[3]_31 CORED00_752 CORED01_754
+  CORED10_756 CORED11_758 CORED20_760 CORED21_762 CORED30_764 CORED31_766
+  NBL[0]_31 NBL[1]_31 NBL[2]_31 NBL[3]_31 NCORED00_768 NCORED01_770
+  NCORED10_772 NCORED11_774 NCORED20_776 NCORED21_778 NCORED30_780
+  NCORED31_782 VDDC_31 VDDCE_31 VDDPE_31 VNWC_32 VPW_32 VPW_0 WL[0] WL[1]
+  sram464x144CCHD4
XMEM_R_COL_32 BL[0]_32 BL[1]_32 BL[2]_32 BL[3]_32 CORED00_816 CORED01_818
+  CORED10_820 CORED11_822 CORED20_824 CORED21_826 CORED30_828 CORED31_830
+  NBL[0]_32 NBL[1]_32 NBL[2]_32 NBL[3]_32 NCORED00_832 NCORED01_834
+  NCORED10_836 NCORED11_838 NCORED20_840 NCORED21_842 NCORED30_844
+  NCORED31_846 VDDC_32 VDDCE_32 VDDPE_32 VNWC_33 VPW_33 VPW_0 WL[0] WL[1]
+  sram464x144CCHD4
XMEM_R_COL_33 BL[0]_33 BL[1]_33 BL[2]_33 BL[3]_33 CORED00_880 CORED01_882
+  CORED10_884 CORED11_886 CORED20_888 CORED21_890 CORED30_892 CORED31_894
+  NBL[0]_33 NBL[1]_33 NBL[2]_33 NBL[3]_33 NCORED00_896 NCORED01_898
+  NCORED10_900 NCORED11_902 NCORED20_904 NCORED21_906 NCORED30_908
+  NCORED31_910 VDDC_33 VDDCE_33 VDDPE_33 VNWC_34 VPW_34 VPW_0 WL[0] WL[1]
+  sram464x144CCHD4
XMEM_R_COL_34 BL[0]_34 BL[1]_34 BL[2]_34 BL[3]_34 CORED00_944 CORED01_946
+  CORED10_948 CORED11_950 CORED20_952 CORED21_954 CORED30_956 CORED31_958
+  NBL[0]_34 NBL[1]_34 NBL[2]_34 NBL[3]_34 NCORED00_960 NCORED01_962
+  NCORED10_964 NCORED11_966 NCORED20_968 NCORED21_970 NCORED30_972
+  NCORED31_974 VDDC_34 VDDCE_34 VDDPE_34 VNWC_35 VPW_35 VPW_0 WL[0] WL[1]
+  sram464x144CCHD4
XMEM_R_COL_35 BL[0]_35 BL[1]_35 BL[2]_35 BL[3]_35 CORED00_1008 CORED01_1010
+  CORED10_1012 CORED11_1014 CORED20_1016 CORED21_1018 CORED30_1020
+  CORED31_1022 NBL[0]_35 NBL[1]_35 NBL[2]_35 NBL[3]_35 NCORED00_1024
+  NCORED01_1026 NCORED10_1028 NCORED11_1030 NCORED20_1032 NCORED21_1034
+  NCORED30_1036 NCORED31_1038 VDDC_35 VDDCE_35 VDDPE_35 VNWC_36 VPW_36 VPW_0
+  WL[0] WL[1] sram464x144CCHD4
XMEM_R_COL_4 BL[0]_4 BL[1]_4 BL[2]_4 BL[3]_4 CORED00_432 CORED01_434
+  CORED10_436 CORED11_438 CORED20_440 CORED21_442 CORED30_444 CORED31_446
+  NBL[0]_4 NBL[1]_4 NBL[2]_4 NBL[3]_4 NCORED00_448 NCORED01_450 NCORED10_452
+  NCORED11_454 NCORED20_456 NCORED21_458 NCORED30_460 NCORED31_462 VDDC_4
+  VDDCE_4 VDDPE_4 VNWC_5 VPW_5 VPW_0 WL[0] WL[1] sram464x144CCHD4
XMEM_R_COL_5 BL[0]_5 BL[1]_5 BL[2]_5 BL[3]_5 CORED00_464 CORED01_466
+  CORED10_468 CORED11_470 CORED20_472 CORED21_474 CORED30_476 CORED31_478
+  NBL[0]_5 NBL[1]_5 NBL[2]_5 NBL[3]_5 NCORED00_480 NCORED01_482 NCORED10_484
+  NCORED11_486 NCORED20_488 NCORED21_490 NCORED30_492 NCORED31_494 VDDC_5
+  VDDCE_5 VDDPE_5 VNWC_6 VPW_6 VPW_0 WL[0] WL[1] sram464x144CCHD4
XMEM_R_COL_6 BL[0]_6 BL[1]_6 BL[2]_6 BL[3]_6 CORED00_496 CORED01_498
+  CORED10_500 CORED11_502 CORED20_504 CORED21_506 CORED30_508 CORED31_510
+  NBL[0]_6 NBL[1]_6 NBL[2]_6 NBL[3]_6 NCORED00_512 NCORED01_514 NCORED10_516
+  NCORED11_518 NCORED20_520 NCORED21_522 NCORED30_524 NCORED31_526 VDDC_6
+  VDDCE_6 VDDPE_6 VNWC_7 VPW_7 VPW_0 WL[0] WL[1] sram464x144CCHD4
XMEM_R_COL_7 BL[0]_7 BL[1]_7 BL[2]_7 BL[3]_7 CORED00_528 CORED01_530
+  CORED10_532 CORED11_534 CORED20_536 CORED21_538 CORED30_540 CORED31_542
+  NBL[0]_7 NBL[1]_7 NBL[2]_7 NBL[3]_7 NCORED00_544 NCORED01_546 NCORED10_548
+  NCORED11_550 NCORED20_552 NCORED21_554 NCORED30_556 NCORED31_558 VDDC_7
+  VDDCE_7 VDDPE_7 VNWC_8 VPW_8 VPW_0 WL[0] WL[1] sram464x144CCHD4
XMEM_R_COL_8 BL[0]_8 BL[1]_8 BL[2]_8 BL[3]_8 CORED00_560 CORED01_562
+  CORED10_564 CORED11_566 CORED20_568 CORED21_570 CORED30_572 CORED31_574
+  NBL[0]_8 NBL[1]_8 NBL[2]_8 NBL[3]_8 NCORED00_576 NCORED01_578 NCORED10_580
+  NCORED11_582 NCORED20_584 NCORED21_586 NCORED30_588 NCORED31_590 VDDC_8
+  VDDCE_8 VDDPE_8 VNWC_9 VPW_9 VPW_0 WL[0] WL[1] sram464x144CCHD4
XMEM_R_COL_9 BL[0]_9 BL[1]_9 BL[2]_9 BL[3]_9 CORED00_592 CORED01_594
+  CORED10_596 CORED11_598 CORED20_600 CORED21_602 CORED30_604 CORED31_606
+  NBL[0]_9 NBL[1]_9 NBL[2]_9 NBL[3]_9 NCORED00_608 NCORED01_610 NCORED10_612
+  NCORED11_614 NCORED20_616 NCORED21_618 NCORED30_620 NCORED31_622 VDDC_9
+  VDDCE_9 VDDPE_9 VNWC_10 VPW_10 VPW_0 WL[0] WL[1] sram464x144CCHD4
XMEM_R_COL_EDGEL VNWC_0 VNWP_0 VPW_0 VPW_0 WL[0] WL[1] sram464x144CCHD4WD_EDG
XMEM_R_COL_EDGER VNWC_37 VNWP_1 VPW_0 VPW_0 WL[0] WL[1] sram464x144CCHD4_EDG
.ENDS sram464x144MEM_R_MID_ROW
****
.SUBCKT sram464x144MEM_R_STRAPROW BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4
+  BL[0]_5 BL[0]_6 BL[0]_7 BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13
+  BL[0]_14 BL[0]_15 BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21
+  BL[0]_22 BL[0]_23 BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29
+  BL[0]_30 BL[0]_31 BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1
+  BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10
+  BL[1]_11 BL[1]_12 BL[1]_13 BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18
+  BL[1]_19 BL[1]_20 BL[1]_21 BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26
+  BL[1]_27 BL[1]_28 BL[1]_29 BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34
+  BL[1]_35 BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7
+  BL[2]_8 BL[2]_9 BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15
+  BL[2]_16 BL[2]_17 BL[2]_18 BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23
+  BL[2]_24 BL[2]_25 BL[2]_26 BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31
+  BL[2]_32 BL[2]_33 BL[2]_34 BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4
+  BL[3]_5 BL[3]_6 BL[3]_7 BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13
+  BL[3]_14 BL[3]_15 BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21
+  BL[3]_22 BL[3]_23 BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29
+  BL[3]_30 BL[3]_31 BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1
+  NBL[0]_2 NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9
+  NBL[0]_10 NBL[0]_11 NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16
+  NBL[0]_17 NBL[0]_18 NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23
+  NBL[0]_24 NBL[0]_25 NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30
+  NBL[0]_31 NBL[0]_32 NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1
+  NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9
+  NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16
+  NBL[1]_17 NBL[1]_18 NBL[1]_19 NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23
+  NBL[1]_24 NBL[1]_25 NBL[1]_26 NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30
+  NBL[1]_31 NBL[1]_32 NBL[1]_33 NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1
+  NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9
+  NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13 NBL[2]_14 NBL[2]_15 NBL[2]_16
+  NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20 NBL[2]_21 NBL[2]_22 NBL[2]_23
+  NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27 NBL[2]_28 NBL[2]_29 NBL[2]_30
+  NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34 NBL[2]_35 NBL[3]_0 NBL[3]_1
+  NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 NBL[3]_8 NBL[3]_9
+  NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13 NBL[3]_14 NBL[3]_15 NBL[3]_16
+  NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20 NBL[3]_21 NBL[3]_22 NBL[3]_23
+  NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27 NBL[3]_28 NBL[3]_29 NBL[3]_30
+  NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34 NBL[3]_35 VDDC_0 VDDC_1 VDDC_2
+  VDDC_3 VDDC_4 VDDC_5 VDDC_6 VDDC_7 VDDC_8 VDDC_9 VDDC_10 VDDC_11 VDDC_12
+  VDDC_13 VDDC_14 VDDC_15 VDDC_16 VDDC_17 VDDC_18 VDDC_19 VDDC_20 VDDC_21
+  VDDC_22 VDDC_23 VDDC_24 VDDC_25 VDDC_26 VDDC_27 VDDC_28 VDDC_29 VDDC_30
+  VDDC_31 VDDC_32 VDDC_33 VDDC_34 VDDC_35 VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3
+  VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8 VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12
+  VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16 VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20
+  VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24 VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28
+  VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32 VDDPE_33 VDDPE_34 VDDPE_35 VNWC VNWP_0
+  VNWP_1 VPW
** sram464x144MEM_R_STRAPROW: 868 flat devices **
XMEM_STRAP0 BL[0]_0 BL[1]_0 BL[2]_0 BL[3]_0 NBL[0]_0 NBL[1]_0 NBL[2]_0
+  NBL[3]_0 VDDC_0 VNWC VDDPE_0 VNWC VPW VPW sram464x144CCHD4_STRAP
XMEM_STRAP1 BL[0]_1 BL[1]_1 BL[2]_1 BL[3]_1 NBL[0]_1 NBL[1]_1 NBL[2]_1
+  NBL[3]_1 VDDC_1 VNWC VDDPE_1 VNWC VPW VPW sram464x144CCHD4_STRAP
XMEM_STRAP10 BL[0]_10 BL[1]_10 BL[2]_10 BL[3]_10 NBL[0]_10 NBL[1]_10 NBL[2]_10
+  NBL[3]_10 VDDC_10 VNWC VDDPE_10 VNWC VPW VPW sram464x144CCHD4_STRAP
XMEM_STRAP11 BL[0]_11 BL[1]_11 BL[2]_11 BL[3]_11 NBL[0]_11 NBL[1]_11 NBL[2]_11
+  NBL[3]_11 VDDC_11 VNWC VDDPE_11 VNWC VPW VPW sram464x144CCHD4_STRAP
XMEM_STRAP12 BL[0]_12 BL[1]_12 BL[2]_12 BL[3]_12 NBL[0]_12 NBL[1]_12 NBL[2]_12
+  NBL[3]_12 VDDC_12 VNWC VDDPE_12 VNWC VPW VPW sram464x144CCHD4_STRAP
XMEM_STRAP13 BL[0]_13 BL[1]_13 BL[2]_13 BL[3]_13 NBL[0]_13 NBL[1]_13 NBL[2]_13
+  NBL[3]_13 VDDC_13 VNWC VDDPE_13 VNWC VPW VPW sram464x144CCHD4_STRAP
XMEM_STRAP14 BL[0]_14 BL[1]_14 BL[2]_14 BL[3]_14 NBL[0]_14 NBL[1]_14 NBL[2]_14
+  NBL[3]_14 VDDC_14 VNWC VDDPE_14 VNWC VPW VPW sram464x144CCHD4_STRAP
XMEM_STRAP15 BL[0]_15 BL[1]_15 BL[2]_15 BL[3]_15 NBL[0]_15 NBL[1]_15 NBL[2]_15
+  NBL[3]_15 VDDC_15 VNWC VDDPE_15 VNWC VPW VPW sram464x144CCHD4_STRAP
XMEM_STRAP16 BL[0]_16 BL[1]_16 BL[2]_16 BL[3]_16 NBL[0]_16 NBL[1]_16 NBL[2]_16
+  NBL[3]_16 VDDC_16 VNWC VDDPE_16 VNWC VPW VPW sram464x144CCHD4_STRAP
XMEM_STRAP17 BL[0]_17 BL[1]_17 BL[2]_17 BL[3]_17 NBL[0]_17 NBL[1]_17 NBL[2]_17
+  NBL[3]_17 VDDC_17 VNWC VDDPE_17 VNWC VPW VPW sram464x144CCHD4_STRAP
XMEM_STRAP18 BL[0]_18 BL[1]_18 BL[2]_18 BL[3]_18 NBL[0]_18 NBL[1]_18 NBL[2]_18
+  NBL[3]_18 VDDC_18 VNWC VDDPE_18 VNWC VPW VPW sram464x144CCHD4_STRAP
XMEM_STRAP19 BL[0]_19 BL[1]_19 BL[2]_19 BL[3]_19 NBL[0]_19 NBL[1]_19 NBL[2]_19
+  NBL[3]_19 VDDC_19 VNWC VDDPE_19 VNWC VPW VPW sram464x144CCHD4_STRAP
XMEM_STRAP2 BL[0]_2 BL[1]_2 BL[2]_2 BL[3]_2 NBL[0]_2 NBL[1]_2 NBL[2]_2
+  NBL[3]_2 VDDC_2 VNWC VDDPE_2 VNWC VPW VPW sram464x144CCHD4_STRAP
XMEM_STRAP20 BL[0]_20 BL[1]_20 BL[2]_20 BL[3]_20 NBL[0]_20 NBL[1]_20 NBL[2]_20
+  NBL[3]_20 VDDC_20 VNWC VDDPE_20 VNWC VPW VPW sram464x144CCHD4_STRAP
XMEM_STRAP21 BL[0]_21 BL[1]_21 BL[2]_21 BL[3]_21 NBL[0]_21 NBL[1]_21 NBL[2]_21
+  NBL[3]_21 VDDC_21 VNWC VDDPE_21 VNWC VPW VPW sram464x144CCHD4_STRAP
XMEM_STRAP22 BL[0]_22 BL[1]_22 BL[2]_22 BL[3]_22 NBL[0]_22 NBL[1]_22 NBL[2]_22
+  NBL[3]_22 VDDC_22 VNWC VDDPE_22 VNWC VPW VPW sram464x144CCHD4_STRAP
XMEM_STRAP23 BL[0]_23 BL[1]_23 BL[2]_23 BL[3]_23 NBL[0]_23 NBL[1]_23 NBL[2]_23
+  NBL[3]_23 VDDC_23 VNWC VDDPE_23 VNWC VPW VPW sram464x144CCHD4_STRAP
XMEM_STRAP24 BL[0]_24 BL[1]_24 BL[2]_24 BL[3]_24 NBL[0]_24 NBL[1]_24 NBL[2]_24
+  NBL[3]_24 VDDC_24 VNWC VDDPE_24 VNWC VPW VPW sram464x144CCHD4_STRAP
XMEM_STRAP25 BL[0]_25 BL[1]_25 BL[2]_25 BL[3]_25 NBL[0]_25 NBL[1]_25 NBL[2]_25
+  NBL[3]_25 VDDC_25 VNWC VDDPE_25 VNWC VPW VPW sram464x144CCHD4_STRAP
XMEM_STRAP26 BL[0]_26 BL[1]_26 BL[2]_26 BL[3]_26 NBL[0]_26 NBL[1]_26 NBL[2]_26
+  NBL[3]_26 VDDC_26 VNWC VDDPE_26 VNWC VPW VPW sram464x144CCHD4_STRAP
XMEM_STRAP27 BL[0]_27 BL[1]_27 BL[2]_27 BL[3]_27 NBL[0]_27 NBL[1]_27 NBL[2]_27
+  NBL[3]_27 VDDC_27 VNWC VDDPE_27 VNWC VPW VPW sram464x144CCHD4_STRAP
XMEM_STRAP28 BL[0]_28 BL[1]_28 BL[2]_28 BL[3]_28 NBL[0]_28 NBL[1]_28 NBL[2]_28
+  NBL[3]_28 VDDC_28 VNWC VDDPE_28 VNWC VPW VPW sram464x144CCHD4_STRAP
XMEM_STRAP29 BL[0]_29 BL[1]_29 BL[2]_29 BL[3]_29 NBL[0]_29 NBL[1]_29 NBL[2]_29
+  NBL[3]_29 VDDC_29 VNWC VDDPE_29 VNWC VPW VPW sram464x144CCHD4_STRAP
XMEM_STRAP3 BL[0]_3 BL[1]_3 BL[2]_3 BL[3]_3 NBL[0]_3 NBL[1]_3 NBL[2]_3
+  NBL[3]_3 VDDC_3 VNWC VDDPE_3 VNWC VPW VPW sram464x144CCHD4_STRAP
XMEM_STRAP30 BL[0]_30 BL[1]_30 BL[2]_30 BL[3]_30 NBL[0]_30 NBL[1]_30 NBL[2]_30
+  NBL[3]_30 VDDC_30 VNWC VDDPE_30 VNWC VPW VPW sram464x144CCHD4_STRAP
XMEM_STRAP31 BL[0]_31 BL[1]_31 BL[2]_31 BL[3]_31 NBL[0]_31 NBL[1]_31 NBL[2]_31
+  NBL[3]_31 VDDC_31 VNWC VDDPE_31 VNWC VPW VPW sram464x144CCHD4_STRAP
XMEM_STRAP32 BL[0]_32 BL[1]_32 BL[2]_32 BL[3]_32 NBL[0]_32 NBL[1]_32 NBL[2]_32
+  NBL[3]_32 VDDC_32 VNWC VDDPE_32 VNWC VPW VPW sram464x144CCHD4_STRAP
XMEM_STRAP33 BL[0]_33 BL[1]_33 BL[2]_33 BL[3]_33 NBL[0]_33 NBL[1]_33 NBL[2]_33
+  NBL[3]_33 VDDC_33 VNWC VDDPE_33 VNWC VPW VPW sram464x144CCHD4_STRAP
XMEM_STRAP34 BL[0]_34 BL[1]_34 BL[2]_34 BL[3]_34 NBL[0]_34 NBL[1]_34 NBL[2]_34
+  NBL[3]_34 VDDC_34 VNWC VDDPE_34 VNWC VPW VPW sram464x144CCHD4_STRAP
XMEM_STRAP35 BL[0]_35 BL[1]_35 BL[2]_35 BL[3]_35 NBL[0]_35 NBL[1]_35 NBL[2]_35
+  NBL[3]_35 VDDC_35 VNWC VDDPE_35 VNWC VPW VPW sram464x144CCHD4_STRAP
XMEM_STRAP4 BL[0]_4 BL[1]_4 BL[2]_4 BL[3]_4 NBL[0]_4 NBL[1]_4 NBL[2]_4
+  NBL[3]_4 VDDC_4 VNWC VDDPE_4 VNWC VPW VPW sram464x144CCHD4_STRAP
XMEM_STRAP5 BL[0]_5 BL[1]_5 BL[2]_5 BL[3]_5 NBL[0]_5 NBL[1]_5 NBL[2]_5
+  NBL[3]_5 VDDC_5 VNWC VDDPE_5 VNWC VPW VPW sram464x144CCHD4_STRAP
XMEM_STRAP6 BL[0]_6 BL[1]_6 BL[2]_6 BL[3]_6 NBL[0]_6 NBL[1]_6 NBL[2]_6
+  NBL[3]_6 VDDC_6 VNWC VDDPE_6 VNWC VPW VPW sram464x144CCHD4_STRAP
XMEM_STRAP7 BL[0]_7 BL[1]_7 BL[2]_7 BL[3]_7 NBL[0]_7 NBL[1]_7 NBL[2]_7
+  NBL[3]_7 VDDC_7 VNWC VDDPE_7 VNWC VPW VPW sram464x144CCHD4_STRAP
XMEM_STRAP8 BL[0]_8 BL[1]_8 BL[2]_8 BL[3]_8 NBL[0]_8 NBL[1]_8 NBL[2]_8
+  NBL[3]_8 VDDC_8 VNWC VDDPE_8 VNWC VPW VPW sram464x144CCHD4_STRAP
XMEM_STRAP9 BL[0]_9 BL[1]_9 BL[2]_9 BL[3]_9 NBL[0]_9 NBL[1]_9 NBL[2]_9
+  NBL[3]_9 VDDC_9 VNWC VDDPE_9 VNWC VPW VPW sram464x144CCHD4_STRAP
XMEM_STRAPEDGEL VNWC VNWP_0 VPW VPW sram464x144CCHD4WD_EDG_STRP
XMEM_STRAPEDGER VNWC VNWP_1 VPW VPW sram464x144CCHD4_EDG_STRAP
.ENDS sram464x144MEM_R_STRAPROW
****
.SUBCKT sram464x144MEM_R_BOT_ROW BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4
+  BL[0]_5 BL[0]_6 BL[0]_7 BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13
+  BL[0]_14 BL[0]_15 BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21
+  BL[0]_22 BL[0]_23 BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29
+  BL[0]_30 BL[0]_31 BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1
+  BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10
+  BL[1]_11 BL[1]_12 BL[1]_13 BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18
+  BL[1]_19 BL[1]_20 BL[1]_21 BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26
+  BL[1]_27 BL[1]_28 BL[1]_29 BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34
+  BL[1]_35 BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7
+  BL[2]_8 BL[2]_9 BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15
+  BL[2]_16 BL[2]_17 BL[2]_18 BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23
+  BL[2]_24 BL[2]_25 BL[2]_26 BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31
+  BL[2]_32 BL[2]_33 BL[2]_34 BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4
+  BL[3]_5 BL[3]_6 BL[3]_7 BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13
+  BL[3]_14 BL[3]_15 BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21
+  BL[3]_22 BL[3]_23 BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29
+  BL[3]_30 BL[3]_31 BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1
+  NBL[0]_2 NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9
+  NBL[0]_10 NBL[0]_11 NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16
+  NBL[0]_17 NBL[0]_18 NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23
+  NBL[0]_24 NBL[0]_25 NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30
+  NBL[0]_31 NBL[0]_32 NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1
+  NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9
+  NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16
+  NBL[1]_17 NBL[1]_18 NBL[1]_19 NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23
+  NBL[1]_24 NBL[1]_25 NBL[1]_26 NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30
+  NBL[1]_31 NBL[1]_32 NBL[1]_33 NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1
+  NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9
+  NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13 NBL[2]_14 NBL[2]_15 NBL[2]_16
+  NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20 NBL[2]_21 NBL[2]_22 NBL[2]_23
+  NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27 NBL[2]_28 NBL[2]_29 NBL[2]_30
+  NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34 NBL[2]_35 NBL[3]_0 NBL[3]_1
+  NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 NBL[3]_8 NBL[3]_9
+  NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13 NBL[3]_14 NBL[3]_15 NBL[3]_16
+  NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20 NBL[3]_21 NBL[3]_22 NBL[3]_23
+  NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27 NBL[3]_28 NBL[3]_29 NBL[3]_30
+  NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34 NBL[3]_35 VDDCE_0 VDDCE_1 VDDCE_2
+  VDDCE_3 VDDCE_4 VDDCE_5 VDDCE_6 VDDCE_7 VDDCE_8 VDDCE_9 VDDCE_10 VDDCE_11
+  VDDCE_12 VDDCE_13 VDDCE_14 VDDCE_15 VDDCE_16 VDDCE_17 VDDCE_18 VDDCE_19
+  VDDCE_20 VDDCE_21 VDDCE_22 VDDCE_23 VDDCE_24 VDDCE_25 VDDCE_26 VDDCE_27
+  VDDCE_28 VDDCE_29 VDDCE_30 VDDCE_31 VDDCE_32 VDDCE_33 VDDCE_34 VDDCE_35
+  VDDC_0 VDDC_1 VDDC_2 VDDC_3 VDDC_4 VDDC_5 VDDC_6 VDDC_7 VDDC_8 VDDC_9
+  VDDC_10 VDDC_11 VDDC_12 VDDC_13 VDDC_14 VDDC_15 VDDC_16 VDDC_17 VDDC_18
+  VDDC_19 VDDC_20 VDDC_21 VDDC_22 VDDC_23 VDDC_24 VDDC_25 VDDC_26 VDDC_27
+  VDDC_28 VDDC_29 VDDC_30 VDDC_31 VDDC_32 VDDC_33 VDDC_34 VDDC_35 VDDPE_0
+  VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8 VDDPE_9
+  VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16 VDDPE_17
+  VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24 VDDPE_25
+  VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32 VDDPE_33
+  VDDPE_34 VDDPE_35 VNWC_0 VNWC_1 VNWC_2 VNWC_3 VNWC_4 VNWC_5 VNWC_6 VNWC_7
+  VNWC_8 VNWC_9 VNWC_10 VNWC_11 VNWC_12 VNWC_13 VNWC_14 VNWC_15 VNWC_16
+  VNWC_17 VNWC_18 VNWC_19 VNWC_20 VNWC_21 VNWC_22 VNWC_23 VNWC_24 VNWC_25
+  VNWC_26 VNWC_27 VNWC_28 VNWC_29 VNWC_30 VNWC_31 VNWC_32 VNWC_33 VNWC_34
+  VNWC_35 VNWC_36 VNWC_37 VNWP_0 VNWP_1 VPW_0 VPW_1 VPW_2 VPW_3 VPW_4 VPW_5
+  VPW_6 VPW_7 VPW_8 VPW_9 VPW_10 VPW_11 VPW_12 VPW_13 VPW_14 VPW_15 VPW_16
+  VPW_17 VPW_18 VPW_19 VPW_20 VPW_21 VPW_22 VPW_23 VPW_24 VPW_25 VPW_26
+  VPW_27 VPW_28 VPW_29 VPW_30 VPW_31 VPW_32 VPW_33 VPW_34 VPW_35 VPW_36 WL[0]
+  WL[1]
** sram464x144MEM_R_BOT_ROW: 1732 flat devices **
XMEM_R_COL_1 BL[0]_1 BL[1]_1 BL[2]_1 BL[3]_1 CORED00_336 CORED01_338
+  CORED10_340 CORED11_342 CORED20_344 CORED21_346 CORED30_348 CORED31_350
+  NBL[0]_1 NBL[1]_1 NBL[2]_1 NBL[3]_1 NCORED00_352 NCORED01_354 NCORED10_356
+  NCORED11_358 NCORED20_360 NCORED21_362 NCORED30_364 NCORED31_366 VDDC_1
+  VDDCE_1 VDDPE_1 VNWC_2 VPW_2 VPW_0 WL[0] WL[1] sram464x144CCHD4
XMEM_R_COL_10 BL[0]_10 BL[1]_10 BL[2]_10 BL[3]_10 CORED00_624 CORED01_626
+  CORED10_628 CORED11_630 CORED20_632 CORED21_634 CORED30_636 CORED31_638
+  NBL[0]_10 NBL[1]_10 NBL[2]_10 NBL[3]_10 NCORED00_640 NCORED01_642
+  NCORED10_644 NCORED11_646 NCORED20_648 NCORED21_650 NCORED30_652
+  NCORED31_654 VDDC_10 VDDCE_10 VDDPE_10 VNWC_11 VPW_11 VPW_0 WL[0] WL[1]
+  sram464x144CCHD4
XMEM_R_COL_11 BL[0]_11 BL[1]_11 BL[2]_11 BL[3]_11 CORED00_656 CORED01_658
+  CORED10_660 CORED11_662 CORED20_664 CORED21_666 CORED30_668 CORED31_670
+  NBL[0]_11 NBL[1]_11 NBL[2]_11 NBL[3]_11 NCORED00_672 NCORED01_674
+  NCORED10_676 NCORED11_678 NCORED20_680 NCORED21_682 NCORED30_684
+  NCORED31_686 VDDC_11 VDDCE_11 VDDPE_11 VNWC_12 VPW_12 VPW_0 WL[0] WL[1]
+  sram464x144CCHD4
XMEM_R_COL_12 BL[0]_12 BL[1]_12 BL[2]_12 BL[3]_12 CORED00_688 CORED01_690
+  CORED10_692 CORED11_694 CORED20_696 CORED21_698 CORED30_700 CORED31_702
+  NBL[0]_12 NBL[1]_12 NBL[2]_12 NBL[3]_12 NCORED00_704 NCORED01_706
+  NCORED10_708 NCORED11_710 NCORED20_712 NCORED21_714 NCORED30_716
+  NCORED31_718 VDDC_12 VDDCE_12 VDDPE_12 VNWC_13 VPW_13 VPW_0 WL[0] WL[1]
+  sram464x144CCHD4
XMEM_R_COL_13 BL[0]_13 BL[1]_13 BL[2]_13 BL[3]_13 CORED00_784 CORED01_786
+  CORED10_788 CORED11_790 CORED20_792 CORED21_794 CORED30_796 CORED31_798
+  NBL[0]_13 NBL[1]_13 NBL[2]_13 NBL[3]_13 NCORED00_800 NCORED01_802
+  NCORED10_804 NCORED11_806 NCORED20_808 NCORED21_810 NCORED30_812
+  NCORED31_814 VDDC_13 VDDCE_13 VDDPE_13 VNWC_14 VPW_14 VPW_0 WL[0] WL[1]
+  sram464x144CCHD4
XMEM_R_COL_14 BL[0]_14 BL[1]_14 BL[2]_14 BL[3]_14 CORED00_848 CORED01_850
+  CORED10_852 CORED11_854 CORED20_856 CORED21_858 CORED30_860 CORED31_862
+  NBL[0]_14 NBL[1]_14 NBL[2]_14 NBL[3]_14 NCORED00_864 NCORED01_866
+  NCORED10_868 NCORED11_870 NCORED20_872 NCORED21_874 NCORED30_876
+  NCORED31_878 VDDC_14 VDDCE_14 VDDPE_14 VNWC_15 VPW_15 VPW_0 WL[0] WL[1]
+  sram464x144CCHD4
XMEM_R_COL_15 BL[0]_15 BL[1]_15 BL[2]_15 BL[3]_15 CORED00_912 CORED01_914
+  CORED10_916 CORED11_918 CORED20_920 CORED21_922 CORED30_924 CORED31_926
+  NBL[0]_15 NBL[1]_15 NBL[2]_15 NBL[3]_15 NCORED00_928 NCORED01_930
+  NCORED10_932 NCORED11_934 NCORED20_936 NCORED21_938 NCORED30_940
+  NCORED31_942 VDDC_15 VDDCE_15 VDDPE_15 VNWC_16 VPW_16 VPW_0 WL[0] WL[1]
+  sram464x144CCHD4
XMEM_R_COL_16 BL[0]_16 BL[1]_16 BL[2]_16 BL[3]_16 CORED00_976 CORED01_978
+  CORED10_980 CORED11_982 CORED20_984 CORED21_986 CORED30_988 CORED31_990
+  NBL[0]_16 NBL[1]_16 NBL[2]_16 NBL[3]_16 NCORED00_992 NCORED01_994
+  NCORED10_996 NCORED11_998 NCORED20_1000 NCORED21_1002 NCORED30_1004
+  NCORED31_1006 VDDC_16 VDDCE_16 VDDPE_16 VNWC_17 VPW_17 VPW_0 WL[0] WL[1]
+  sram464x144CCHD4
XMEM_R_COL_17 BL[0]_17 BL[1]_17 BL[2]_17 BL[3]_17 CORED00_1008 CORED01_1010
+  CORED10_1012 CORED11_1014 CORED20_1016 CORED21_1018 CORED30_1020
+  CORED31_1022 NBL[0]_17 NBL[1]_17 NBL[2]_17 NBL[3]_17 NCORED00_1024
+  NCORED01_1026 NCORED10_1028 NCORED11_1030 NCORED20_1032 NCORED21_1034
+  NCORED30_1036 NCORED31_1038 VDDC_17 VDDCE_17 VDDPE_17 VNWC_18 VPW_18 VPW_0
+  WL[0] WL[1] sram464x144CCHD4
XMEM_R_COL_18 BL[0]_18 BL[1]_18 BL[2]_18 BL[3]_18 CORED00_1040 CORED01_1042
+  CORED10_1044 CORED11_1046 CORED20_1048 CORED21_1050 CORED30_1052
+  CORED31_1054 NBL[0]_18 NBL[1]_18 NBL[2]_18 NBL[3]_18 NCORED00_1056
+  NCORED01_1058 NCORED10_1060 NCORED11_1062 NCORED20_1064 NCORED21_1066
+  NCORED30_1068 NCORED31_1070 VDDC_18 VDDCE_18 VDDPE_18 VNWC_19 VPW_19 VPW_0
+  WL[0] WL[1] sram464x144CCHD4
XMEM_R_COL_19 BL[0]_19 BL[1]_19 BL[2]_19 BL[3]_19 CORED00_1072 CORED01_1074
+  CORED10_1076 CORED11_1078 CORED20_1080 CORED21_1082 CORED30_1084
+  CORED31_1086 NBL[0]_19 NBL[1]_19 NBL[2]_19 NBL[3]_19 NCORED00_1088
+  NCORED01_1090 NCORED10_1092 NCORED11_1094 NCORED20_1096 NCORED21_1098
+  NCORED30_1100 NCORED31_1102 VDDC_19 VDDCE_19 VDDPE_19 VNWC_20 VPW_20 VPW_0
+  WL[0] WL[1] sram464x144CCHD4
XMEM_R_COL_2 BL[0]_2 BL[1]_2 BL[2]_2 BL[3]_2 CORED00_368 CORED01_370
+  CORED10_372 CORED11_374 CORED20_376 CORED21_378 CORED30_380 CORED31_382
+  NBL[0]_2 NBL[1]_2 NBL[2]_2 NBL[3]_2 NCORED00_384 NCORED01_386 NCORED10_388
+  NCORED11_390 NCORED20_392 NCORED21_394 NCORED30_396 NCORED31_398 VDDC_2
+  VDDCE_2 VDDPE_2 VNWC_3 VPW_3 VPW_0 WL[0] WL[1] sram464x144CCHD4
XMEM_R_COL_20 BL[0]_20 BL[1]_20 BL[2]_20 BL[3]_20 CORED00_16 CORED01_18
+  CORED10_20 CORED11_22 CORED20_24 CORED21_26 CORED30_28 CORED31_30 NBL[0]_20
+  NBL[1]_20 NBL[2]_20 NBL[3]_20 NCORED00_32 NCORED01_34 NCORED10_36
+  NCORED11_38 NCORED20_40 NCORED21_42 NCORED30_44 NCORED31_46 VDDC_20
+  VDDCE_20 VDDPE_20 VNWC_21 VPW_21 VPW_0 WL[0] WL[1] sram464x144CCHD4
XMEM_R_COL_21 BL[0]_21 BL[1]_21 BL[2]_21 BL[3]_21 CORED00_48 CORED01_50
+  CORED10_52 CORED11_54 CORED20_56 CORED21_58 CORED30_60 CORED31_62 NBL[0]_21
+  NBL[1]_21 NBL[2]_21 NBL[3]_21 NCORED00_64 NCORED01_66 NCORED10_68
+  NCORED11_70 NCORED20_72 NCORED21_74 NCORED30_76 NCORED31_78 VDDC_21
+  VDDCE_21 VDDPE_21 VNWC_22 VPW_22 VPW_0 WL[0] WL[1] sram464x144CCHD4
XMEM_R_COL_22 BL[0]_22 BL[1]_22 BL[2]_22 BL[3]_22 CORED00_80 CORED01_82
+  CORED10_84 CORED11_86 CORED20_88 CORED21_90 CORED30_92 CORED31_94 NBL[0]_22
+  NBL[1]_22 NBL[2]_22 NBL[3]_22 NCORED00_96 NCORED01_98 NCORED10_100
+  NCORED11_102 NCORED20_104 NCORED21_106 NCORED30_108 NCORED31_110 VDDC_22
+  VDDCE_22 VDDPE_22 VNWC_23 VPW_23 VPW_0 WL[0] WL[1] sram464x144CCHD4
XMEM_R_COL_23 BL[0]_23 BL[1]_23 BL[2]_23 BL[3]_23 CORED00_112 CORED01_114
+  CORED10_116 CORED11_118 CORED20_120 CORED21_122 CORED30_124 CORED31_126
+  NBL[0]_23 NBL[1]_23 NBL[2]_23 NBL[3]_23 NCORED00_128 NCORED01_130
+  NCORED10_132 NCORED11_134 NCORED20_136 NCORED21_138 NCORED30_140
+  NCORED31_142 VDDC_23 VDDCE_23 VDDPE_23 VNWC_24 VPW_24 VPW_0 WL[0] WL[1]
+  sram464x144CCHD4
XMEM_R_COL_24 BL[0]_24 BL[1]_24 BL[2]_24 BL[3]_24 CORED00_144 CORED01_146
+  CORED10_148 CORED11_150 CORED20_152 CORED21_154 CORED30_156 CORED31_158
+  NBL[0]_24 NBL[1]_24 NBL[2]_24 NBL[3]_24 NCORED00_160 NCORED01_162
+  NCORED10_164 NCORED11_166 NCORED20_168 NCORED21_170 NCORED30_172
+  NCORED31_174 VDDC_24 VDDCE_24 VDDPE_24 VNWC_25 VPW_25 VPW_0 WL[0] WL[1]
+  sram464x144CCHD4
XMEM_R_COL_25 BL[0]_25 BL[1]_25 BL[2]_25 BL[3]_25 CORED00_176 CORED01_178
+  CORED10_180 CORED11_182 CORED20_184 CORED21_186 CORED30_188 CORED31_190
+  NBL[0]_25 NBL[1]_25 NBL[2]_25 NBL[3]_25 NCORED00_192 NCORED01_194
+  NCORED10_196 NCORED11_198 NCORED20_200 NCORED21_202 NCORED30_204
+  NCORED31_206 VDDC_25 VDDCE_25 VDDPE_25 VNWC_26 VPW_26 VPW_0 WL[0] WL[1]
+  sram464x144CCHD4
XMEM_R_COL_26 BL[0]_26 BL[1]_26 BL[2]_26 BL[3]_26 CORED00_208 CORED01_210
+  CORED10_212 CORED11_214 CORED20_216 CORED21_218 CORED30_220 CORED31_222
+  NBL[0]_26 NBL[1]_26 NBL[2]_26 NBL[3]_26 NCORED00_224 NCORED01_226
+  NCORED10_228 NCORED11_230 NCORED20_232 NCORED21_234 NCORED30_236
+  NCORED31_238 VDDC_26 VDDCE_26 VDDPE_26 VNWC_27 VPW_27 VPW_0 WL[0] WL[1]
+  sram464x144CCHD4
XMEM_R_COL_27 BL[0]_27 BL[1]_27 BL[2]_27 BL[3]_27 CORED00_240 CORED01_242
+  CORED10_244 CORED11_246 CORED20_248 CORED21_250 CORED30_252 CORED31_254
+  NBL[0]_27 NBL[1]_27 NBL[2]_27 NBL[3]_27 NCORED00_256 NCORED01_258
+  NCORED10_260 NCORED11_262 NCORED20_264 NCORED21_266 NCORED30_268
+  NCORED31_270 VDDC_27 VDDCE_27 VDDPE_27 VNWC_28 VPW_28 VPW_0 WL[0] WL[1]
+  sram464x144CCHD4
XMEM_R_COL_28 BL[0]_28 BL[1]_28 BL[2]_28 BL[3]_28 CORED00_272 CORED01_274
+  CORED10_276 CORED11_278 CORED20_280 CORED21_282 CORED30_284 CORED31_286
+  NBL[0]_28 NBL[1]_28 NBL[2]_28 NBL[3]_28 NCORED00_288 NCORED01_290
+  NCORED10_292 NCORED11_294 NCORED20_296 NCORED21_298 NCORED30_300
+  NCORED31_302 VDDC_28 VDDCE_28 VDDPE_28 VNWC_29 VPW_29 VPW_0 WL[0] WL[1]
+  sram464x144CCHD4
XMEM_R_COL_29 BL[0]_29 BL[1]_29 BL[2]_29 BL[3]_29 CORED00_304 CORED01_306
+  CORED10_308 CORED11_310 CORED20_312 CORED21_314 CORED30_316 CORED31_318
+  NBL[0]_29 NBL[1]_29 NBL[2]_29 NBL[3]_29 NCORED00_320 NCORED01_322
+  NCORED10_324 NCORED11_326 NCORED20_328 NCORED21_330 NCORED30_332
+  NCORED31_334 VDDC_29 VDDCE_29 VDDPE_29 VNWC_30 VPW_30 VPW_0 WL[0] WL[1]
+  sram464x144CCHD4
XMEM_R_COL_3 BL[0]_3 BL[1]_3 BL[2]_3 BL[3]_3 CORED00_400 CORED01_402
+  CORED10_404 CORED11_406 CORED20_408 CORED21_410 CORED30_412 CORED31_414
+  NBL[0]_3 NBL[1]_3 NBL[2]_3 NBL[3]_3 NCORED00_416 NCORED01_418 NCORED10_420
+  NCORED11_422 NCORED20_424 NCORED21_426 NCORED30_428 NCORED31_430 VDDC_3
+  VDDCE_3 VDDPE_3 VNWC_4 VPW_4 VPW_0 WL[0] WL[1] sram464x144CCHD4
XMEM_R_COL_30 BL[0]_30 BL[1]_30 BL[2]_30 BL[3]_30 CORED00_720 CORED01_722
+  CORED10_724 CORED11_726 CORED20_728 CORED21_730 CORED30_732 CORED31_734
+  NBL[0]_30 NBL[1]_30 NBL[2]_30 NBL[3]_30 NCORED00_736 NCORED01_738
+  NCORED10_740 NCORED11_742 NCORED20_744 NCORED21_746 NCORED30_748
+  NCORED31_750 VDDC_30 VDDCE_30 VDDPE_30 VNWC_31 VPW_31 VPW_0 WL[0] WL[1]
+  sram464x144CCHD4
XMEM_R_COL_31 BL[0]_31 BL[1]_31 BL[2]_31 BL[3]_31 CORED00_752 CORED01_754
+  CORED10_756 CORED11_758 CORED20_760 CORED21_762 CORED30_764 CORED31_766
+  NBL[0]_31 NBL[1]_31 NBL[2]_31 NBL[3]_31 NCORED00_768 NCORED01_770
+  NCORED10_772 NCORED11_774 NCORED20_776 NCORED21_778 NCORED30_780
+  NCORED31_782 VDDC_31 VDDCE_31 VDDPE_31 VNWC_32 VPW_32 VPW_0 WL[0] WL[1]
+  sram464x144CCHD4
XMEM_R_COL_32 BL[0]_32 BL[1]_32 BL[2]_32 BL[3]_32 CORED00_816 CORED01_818
+  CORED10_820 CORED11_822 CORED20_824 CORED21_826 CORED30_828 CORED31_830
+  NBL[0]_32 NBL[1]_32 NBL[2]_32 NBL[3]_32 NCORED00_832 NCORED01_834
+  NCORED10_836 NCORED11_838 NCORED20_840 NCORED21_842 NCORED30_844
+  NCORED31_846 VDDC_32 VDDCE_32 VDDPE_32 VNWC_33 VPW_33 VPW_0 WL[0] WL[1]
+  sram464x144CCHD4
XMEM_R_COL_33 BL[0]_33 BL[1]_33 BL[2]_33 BL[3]_33 CORED00_880 CORED01_882
+  CORED10_884 CORED11_886 CORED20_888 CORED21_890 CORED30_892 CORED31_894
+  NBL[0]_33 NBL[1]_33 NBL[2]_33 NBL[3]_33 NCORED00_896 NCORED01_898
+  NCORED10_900 NCORED11_902 NCORED20_904 NCORED21_906 NCORED30_908
+  NCORED31_910 VDDC_33 VDDCE_33 VDDPE_33 VNWC_34 VPW_34 VPW_0 WL[0] WL[1]
+  sram464x144CCHD4
XMEM_R_COL_34 BL[0]_34 BL[1]_34 BL[2]_34 BL[3]_34 CORED00_944 CORED01_946
+  CORED10_948 CORED11_950 CORED20_952 CORED21_954 CORED30_956 CORED31_958
+  NBL[0]_34 NBL[1]_34 NBL[2]_34 NBL[3]_34 NCORED00_960 NCORED01_962
+  NCORED10_964 NCORED11_966 NCORED20_968 NCORED21_970 NCORED30_972
+  NCORED31_974 VDDC_34 VDDCE_34 VDDPE_34 VNWC_35 VPW_35 VPW_0 WL[0] WL[1]
+  sram464x144CCHD4
XMEM_R_COL_4 BL[0]_4 BL[1]_4 BL[2]_4 BL[3]_4 CORED00_432 CORED01_434
+  CORED10_436 CORED11_438 CORED20_440 CORED21_442 CORED30_444 CORED31_446
+  NBL[0]_4 NBL[1]_4 NBL[2]_4 NBL[3]_4 NCORED00_448 NCORED01_450 NCORED10_452
+  NCORED11_454 NCORED20_456 NCORED21_458 NCORED30_460 NCORED31_462 VDDC_4
+  VDDCE_4 VDDPE_4 VNWC_5 VPW_5 VPW_0 WL[0] WL[1] sram464x144CCHD4
XMEM_R_COL_5 BL[0]_5 BL[1]_5 BL[2]_5 BL[3]_5 CORED00_464 CORED01_466
+  CORED10_468 CORED11_470 CORED20_472 CORED21_474 CORED30_476 CORED31_478
+  NBL[0]_5 NBL[1]_5 NBL[2]_5 NBL[3]_5 NCORED00_480 NCORED01_482 NCORED10_484
+  NCORED11_486 NCORED20_488 NCORED21_490 NCORED30_492 NCORED31_494 VDDC_5
+  VDDCE_5 VDDPE_5 VNWC_6 VPW_6 VPW_0 WL[0] WL[1] sram464x144CCHD4
XMEM_R_COL_6 BL[0]_6 BL[1]_6 BL[2]_6 BL[3]_6 CORED00_496 CORED01_498
+  CORED10_500 CORED11_502 CORED20_504 CORED21_506 CORED30_508 CORED31_510
+  NBL[0]_6 NBL[1]_6 NBL[2]_6 NBL[3]_6 NCORED00_512 NCORED01_514 NCORED10_516
+  NCORED11_518 NCORED20_520 NCORED21_522 NCORED30_524 NCORED31_526 VDDC_6
+  VDDCE_6 VDDPE_6 VNWC_7 VPW_7 VPW_0 WL[0] WL[1] sram464x144CCHD4
XMEM_R_COL_7 BL[0]_7 BL[1]_7 BL[2]_7 BL[3]_7 CORED00_528 CORED01_530
+  CORED10_532 CORED11_534 CORED20_536 CORED21_538 CORED30_540 CORED31_542
+  NBL[0]_7 NBL[1]_7 NBL[2]_7 NBL[3]_7 NCORED00_544 NCORED01_546 NCORED10_548
+  NCORED11_550 NCORED20_552 NCORED21_554 NCORED30_556 NCORED31_558 VDDC_7
+  VDDCE_7 VDDPE_7 VNWC_8 VPW_8 VPW_0 WL[0] WL[1] sram464x144CCHD4
XMEM_R_COL_8 BL[0]_8 BL[1]_8 BL[2]_8 BL[3]_8 CORED00_560 CORED01_562
+  CORED10_564 CORED11_566 CORED20_568 CORED21_570 CORED30_572 CORED31_574
+  NBL[0]_8 NBL[1]_8 NBL[2]_8 NBL[3]_8 NCORED00_576 NCORED01_578 NCORED10_580
+  NCORED11_582 NCORED20_584 NCORED21_586 NCORED30_588 NCORED31_590 VDDC_8
+  VDDCE_8 VDDPE_8 VNWC_9 VPW_9 VPW_0 WL[0] WL[1] sram464x144CCHD4
XMEM_R_COL_9 BL[0]_9 BL[1]_9 BL[2]_9 BL[3]_9 CORED00_592 CORED01_594
+  CORED10_596 CORED11_598 CORED20_600 CORED21_602 CORED30_604 CORED31_606
+  NBL[0]_9 NBL[1]_9 NBL[2]_9 NBL[3]_9 NCORED00_608 NCORED01_610 NCORED10_612
+  NCORED11_614 NCORED20_616 NCORED21_618 NCORED30_620 NCORED31_622 VDDC_9
+  VDDCE_9 VDDPE_9 VNWC_10 VPW_10 VPW_0 WL[0] WL[1] sram464x144CCHD4
XMEM_R_COL_BOT_L BL[0]_0 BL[1]_0 BL[2]_0 BL[3]_0 CORED00_1104 CORED01_1106
+  CORED10_1108 CORED11_1110 CORED20_1112 CORED21_1114 CORED30_1116
+  CORED31_1118 NBL[0]_0 NBL[1]_0 NBL[2]_0 NBL[3]_0 NCORED00_1120
+  NCORED01_1122 NCORED10_1124 NCORED11_1126 NCORED20_1128 NCORED21_1130
+  NCORED30_1132 NCORED31_1134 VDDC_0 VDDCE_0 VDDPE_0 VNWC_1 VPW_1 VPW_0 WL[0]
+  WL[1] sram464x144CCHD4
XMEM_R_COL_BOT_R BL[0]_35 BL[1]_35 BL[2]_35 BL[3]_35 CORED00 CORED01 CORED10
+  CORED11 CORED20 CORED21 CORED30 CORED31 NBL[0]_35 NBL[1]_35 NBL[2]_35
+  NBL[3]_35 NCORED00 NCORED01 NCORED10 NCORED11 NCORED20 NCORED21 NCORED30
+  NCORED31 VDDC_35 VDDCE_35 VDDPE_35 VNWC_36 VPW_36 VPW_0 WL[0] WL[1]
+  sram464x144CCHD4
XMEM_R_COL_EDGEL VNWC_0 VNWP_0 VPW_0 VPW_0 WL[0] WL[1] sram464x144CCHD4WD_EDG
XMEM_R_COL_EDGER VNWC_37 VNWP_1 VPW_0 VPW_0 WL[0] WL[1] sram464x144CCHD4_EDG
.ENDS sram464x144MEM_R_BOT_ROW
****
.SUBCKT sram464x144MEM_R_TOP_ROW BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4
+  BL[0]_5 BL[0]_6 BL[0]_7 BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13
+  BL[0]_14 BL[0]_15 BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21
+  BL[0]_22 BL[0]_23 BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29
+  BL[0]_30 BL[0]_31 BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1
+  BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10
+  BL[1]_11 BL[1]_12 BL[1]_13 BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18
+  BL[1]_19 BL[1]_20 BL[1]_21 BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26
+  BL[1]_27 BL[1]_28 BL[1]_29 BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34
+  BL[1]_35 BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7
+  BL[2]_8 BL[2]_9 BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15
+  BL[2]_16 BL[2]_17 BL[2]_18 BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23
+  BL[2]_24 BL[2]_25 BL[2]_26 BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31
+  BL[2]_32 BL[2]_33 BL[2]_34 BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4
+  BL[3]_5 BL[3]_6 BL[3]_7 BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13
+  BL[3]_14 BL[3]_15 BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21
+  BL[3]_22 BL[3]_23 BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29
+  BL[3]_30 BL[3]_31 BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1
+  NBL[0]_2 NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9
+  NBL[0]_10 NBL[0]_11 NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16
+  NBL[0]_17 NBL[0]_18 NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23
+  NBL[0]_24 NBL[0]_25 NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30
+  NBL[0]_31 NBL[0]_32 NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1
+  NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9
+  NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16
+  NBL[1]_17 NBL[1]_18 NBL[1]_19 NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23
+  NBL[1]_24 NBL[1]_25 NBL[1]_26 NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30
+  NBL[1]_31 NBL[1]_32 NBL[1]_33 NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1
+  NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9
+  NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13 NBL[2]_14 NBL[2]_15 NBL[2]_16
+  NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20 NBL[2]_21 NBL[2]_22 NBL[2]_23
+  NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27 NBL[2]_28 NBL[2]_29 NBL[2]_30
+  NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34 NBL[2]_35 NBL[3]_0 NBL[3]_1
+  NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 NBL[3]_8 NBL[3]_9
+  NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13 NBL[3]_14 NBL[3]_15 NBL[3]_16
+  NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20 NBL[3]_21 NBL[3]_22 NBL[3]_23
+  NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27 NBL[3]_28 NBL[3]_29 NBL[3]_30
+  NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34 NBL[3]_35 VDDCE_0 VDDCE_1 VDDCE_2
+  VDDCE_3 VDDCE_4 VDDCE_5 VDDCE_6 VDDCE_7 VDDCE_8 VDDCE_9 VDDCE_10 VDDCE_11
+  VDDCE_12 VDDCE_13 VDDCE_14 VDDCE_15 VDDCE_16 VDDCE_17 VDDCE_18 VDDCE_19
+  VDDCE_20 VDDCE_21 VDDCE_22 VDDCE_23 VDDCE_24 VDDCE_25 VDDCE_26 VDDCE_27
+  VDDCE_28 VDDCE_29 VDDCE_30 VDDCE_31 VDDCE_32 VDDCE_33 VDDCE_34 VDDCE_35
+  VDDC_0 VDDC_1 VDDC_2 VDDC_3 VDDC_4 VDDC_5 VDDC_6 VDDC_7 VDDC_8 VDDC_9
+  VDDC_10 VDDC_11 VDDC_12 VDDC_13 VDDC_14 VDDC_15 VDDC_16 VDDC_17 VDDC_18
+  VDDC_19 VDDC_20 VDDC_21 VDDC_22 VDDC_23 VDDC_24 VDDC_25 VDDC_26 VDDC_27
+  VDDC_28 VDDC_29 VDDC_30 VDDC_31 VDDC_32 VDDC_33 VDDC_34 VDDC_35 VDDPE_0
+  VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8 VDDPE_9
+  VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16 VDDPE_17
+  VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24 VDDPE_25
+  VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32 VDDPE_33
+  VDDPE_34 VDDPE_35 VNWC_0 VNWC_1 VNWC_2 VNWC_3 VNWC_4 VNWC_5 VNWC_6 VNWC_7
+  VNWC_8 VNWC_9 VNWC_10 VNWC_11 VNWC_12 VNWC_13 VNWC_14 VNWC_15 VNWC_16
+  VNWC_17 VNWC_18 VNWC_19 VNWC_20 VNWC_21 VNWC_22 VNWC_23 VNWC_24 VNWC_25
+  VNWC_26 VNWC_27 VNWC_28 VNWC_29 VNWC_30 VNWC_31 VNWC_32 VNWC_33 VNWC_34
+  VNWC_35 VNWC_36 VNWC_37 VNWP_0 VNWP_1 VPW_0 VPW_1 VPW_2 VPW_3 VPW_4 VPW_5
+  VPW_6 VPW_7 VPW_8 VPW_9 VPW_10 VPW_11 VPW_12 VPW_13 VPW_14 VPW_15 VPW_16
+  VPW_17 VPW_18 VPW_19 VPW_20 VPW_21 VPW_22 VPW_23 VPW_24 VPW_25 VPW_26
+  VPW_27 VPW_28 VPW_29 VPW_30 VPW_31 VPW_32 VPW_33 VPW_34 VPW_35 VPW_36 WL[0]
+  WL[1]
** sram464x144MEM_R_TOP_ROW: 1732 flat devices **
XMEM_R_COL_1 BL[0]_1 BL[1]_1 BL[2]_1 BL[3]_1 CORED00_368 CORED01_370
+  CORED10_372 CORED11_374 CORED20_376 CORED21_378 CORED30_380 CORED31_382
+  NBL[0]_1 NBL[1]_1 NBL[2]_1 NBL[3]_1 NCORED00_384 NCORED01_386 NCORED10_388
+  NCORED11_390 NCORED20_392 NCORED21_394 NCORED30_396 NCORED31_398 VDDC_1
+  VDDCE_1 VDDPE_1 VNWC_2 VPW_2 VPW_0 WL[0] WL[1] sram464x144CCHD4
XMEM_R_COL_10 BL[0]_10 BL[1]_10 BL[2]_10 BL[3]_10 CORED00_656 CORED01_658
+  CORED10_660 CORED11_662 CORED20_664 CORED21_666 CORED30_668 CORED31_670
+  NBL[0]_10 NBL[1]_10 NBL[2]_10 NBL[3]_10 NCORED00_672 NCORED01_674
+  NCORED10_676 NCORED11_678 NCORED20_680 NCORED21_682 NCORED30_684
+  NCORED31_686 VDDC_10 VDDCE_10 VDDPE_10 VNWC_11 VPW_11 VPW_0 WL[0] WL[1]
+  sram464x144CCHD4
XMEM_R_COL_11 BL[0]_11 BL[1]_11 BL[2]_11 BL[3]_11 CORED00_688 CORED01_690
+  CORED10_692 CORED11_694 CORED20_696 CORED21_698 CORED30_700 CORED31_702
+  NBL[0]_11 NBL[1]_11 NBL[2]_11 NBL[3]_11 NCORED00_704 NCORED01_706
+  NCORED10_708 NCORED11_710 NCORED20_712 NCORED21_714 NCORED30_716
+  NCORED31_718 VDDC_11 VDDCE_11 VDDPE_11 VNWC_12 VPW_12 VPW_0 WL[0] WL[1]
+  sram464x144CCHD4
XMEM_R_COL_12 BL[0]_12 BL[1]_12 BL[2]_12 BL[3]_12 CORED00_720 CORED01_722
+  CORED10_724 CORED11_726 CORED20_728 CORED21_730 CORED30_732 CORED31_734
+  NBL[0]_12 NBL[1]_12 NBL[2]_12 NBL[3]_12 NCORED00_736 NCORED01_738
+  NCORED10_740 NCORED11_742 NCORED20_744 NCORED21_746 NCORED30_748
+  NCORED31_750 VDDC_12 VDDCE_12 VDDPE_12 VNWC_13 VPW_13 VPW_0 WL[0] WL[1]
+  sram464x144CCHD4
XMEM_R_COL_13 BL[0]_13 BL[1]_13 BL[2]_13 BL[3]_13 CORED00_816 CORED01_818
+  CORED10_820 CORED11_822 CORED20_824 CORED21_826 CORED30_828 CORED31_830
+  NBL[0]_13 NBL[1]_13 NBL[2]_13 NBL[3]_13 NCORED00_832 NCORED01_834
+  NCORED10_836 NCORED11_838 NCORED20_840 NCORED21_842 NCORED30_844
+  NCORED31_846 VDDC_13 VDDCE_13 VDDPE_13 VNWC_14 VPW_14 VPW_0 WL[0] WL[1]
+  sram464x144CCHD4
XMEM_R_COL_14 BL[0]_14 BL[1]_14 BL[2]_14 BL[3]_14 CORED00_880 CORED01_882
+  CORED10_884 CORED11_886 CORED20_888 CORED21_890 CORED30_892 CORED31_894
+  NBL[0]_14 NBL[1]_14 NBL[2]_14 NBL[3]_14 NCORED00_896 NCORED01_898
+  NCORED10_900 NCORED11_902 NCORED20_904 NCORED21_906 NCORED30_908
+  NCORED31_910 VDDC_14 VDDCE_14 VDDPE_14 VNWC_15 VPW_15 VPW_0 WL[0] WL[1]
+  sram464x144CCHD4
XMEM_R_COL_15 BL[0]_15 BL[1]_15 BL[2]_15 BL[3]_15 CORED00_944 CORED01_946
+  CORED10_948 CORED11_950 CORED20_952 CORED21_954 CORED30_956 CORED31_958
+  NBL[0]_15 NBL[1]_15 NBL[2]_15 NBL[3]_15 NCORED00_960 NCORED01_962
+  NCORED10_964 NCORED11_966 NCORED20_968 NCORED21_970 NCORED30_972
+  NCORED31_974 VDDC_15 VDDCE_15 VDDPE_15 VNWC_16 VPW_16 VPW_0 WL[0] WL[1]
+  sram464x144CCHD4
XMEM_R_COL_16 BL[0]_16 BL[1]_16 BL[2]_16 BL[3]_16 CORED00_1008 CORED01_1010
+  CORED10_1012 CORED11_1014 CORED20_1016 CORED21_1018 CORED30_1020
+  CORED31_1022 NBL[0]_16 NBL[1]_16 NBL[2]_16 NBL[3]_16 NCORED00_1024
+  NCORED01_1026 NCORED10_1028 NCORED11_1030 NCORED20_1032 NCORED21_1034
+  NCORED30_1036 NCORED31_1038 VDDC_16 VDDCE_16 VDDPE_16 VNWC_17 VPW_17 VPW_0
+  WL[0] WL[1] sram464x144CCHD4
XMEM_R_COL_17 BL[0]_17 BL[1]_17 BL[2]_17 BL[3]_17 CORED00_1040 CORED01_1042
+  CORED10_1044 CORED11_1046 CORED20_1048 CORED21_1050 CORED30_1052
+  CORED31_1054 NBL[0]_17 NBL[1]_17 NBL[2]_17 NBL[3]_17 NCORED00_1056
+  NCORED01_1058 NCORED10_1060 NCORED11_1062 NCORED20_1064 NCORED21_1066
+  NCORED30_1068 NCORED31_1070 VDDC_17 VDDCE_17 VDDPE_17 VNWC_18 VPW_18 VPW_0
+  WL[0] WL[1] sram464x144CCHD4
XMEM_R_COL_18 BL[0]_18 BL[1]_18 BL[2]_18 BL[3]_18 CORED00_1072 CORED01_1074
+  CORED10_1076 CORED11_1078 CORED20_1080 CORED21_1082 CORED30_1084
+  CORED31_1086 NBL[0]_18 NBL[1]_18 NBL[2]_18 NBL[3]_18 NCORED00_1088
+  NCORED01_1090 NCORED10_1092 NCORED11_1094 NCORED20_1096 NCORED21_1098
+  NCORED30_1100 NCORED31_1102 VDDC_18 VDDCE_18 VDDPE_18 VNWC_19 VPW_19 VPW_0
+  WL[0] WL[1] sram464x144CCHD4
XMEM_R_COL_19 BL[0]_19 BL[1]_19 BL[2]_19 BL[3]_19 CORED00_1104 CORED01_1106
+  CORED10_1108 CORED11_1110 CORED20_1112 CORED21_1114 CORED30_1116
+  CORED31_1118 NBL[0]_19 NBL[1]_19 NBL[2]_19 NBL[3]_19 NCORED00_1120
+  NCORED01_1122 NCORED10_1124 NCORED11_1126 NCORED20_1128 NCORED21_1130
+  NCORED30_1132 NCORED31_1134 VDDC_19 VDDCE_19 VDDPE_19 VNWC_20 VPW_20 VPW_0
+  WL[0] WL[1] sram464x144CCHD4
XMEM_R_COL_2 BL[0]_2 BL[1]_2 BL[2]_2 BL[3]_2 CORED00_400 CORED01_402
+  CORED10_404 CORED11_406 CORED20_408 CORED21_410 CORED30_412 CORED31_414
+  NBL[0]_2 NBL[1]_2 NBL[2]_2 NBL[3]_2 NCORED00_416 NCORED01_418 NCORED10_420
+  NCORED11_422 NCORED20_424 NCORED21_426 NCORED30_428 NCORED31_430 VDDC_2
+  VDDCE_2 VDDPE_2 VNWC_3 VPW_3 VPW_0 WL[0] WL[1] sram464x144CCHD4
XMEM_R_COL_20 BL[0]_20 BL[1]_20 BL[2]_20 BL[3]_20 CORED00_16 CORED01_18
+  CORED10_20 CORED11_22 CORED20_24 CORED21_26 CORED30_28 CORED31_30 NBL[0]_20
+  NBL[1]_20 NBL[2]_20 NBL[3]_20 NCORED00_32 NCORED01_34 NCORED10_36
+  NCORED11_38 NCORED20_40 NCORED21_42 NCORED30_44 NCORED31_46 VDDC_20
+  VDDCE_20 VDDPE_20 VNWC_21 VPW_21 VPW_0 WL[0] WL[1] sram464x144CCHD4
XMEM_R_COL_21 BL[0]_21 BL[1]_21 BL[2]_21 BL[3]_21 CORED00_48 CORED01_50
+  CORED10_52 CORED11_54 CORED20_56 CORED21_58 CORED30_60 CORED31_62 NBL[0]_21
+  NBL[1]_21 NBL[2]_21 NBL[3]_21 NCORED00_64 NCORED01_66 NCORED10_68
+  NCORED11_70 NCORED20_72 NCORED21_74 NCORED30_76 NCORED31_78 VDDC_21
+  VDDCE_21 VDDPE_21 VNWC_22 VPW_22 VPW_0 WL[0] WL[1] sram464x144CCHD4
XMEM_R_COL_22 BL[0]_22 BL[1]_22 BL[2]_22 BL[3]_22 CORED00_112 CORED01_114
+  CORED10_116 CORED11_118 CORED20_120 CORED21_122 CORED30_124 CORED31_126
+  NBL[0]_22 NBL[1]_22 NBL[2]_22 NBL[3]_22 NCORED00_128 NCORED01_130
+  NCORED10_132 NCORED11_134 NCORED20_136 NCORED21_138 NCORED30_140
+  NCORED31_142 VDDC_22 VDDCE_22 VDDPE_22 VNWC_23 VPW_23 VPW_0 WL[0] WL[1]
+  sram464x144CCHD4
XMEM_R_COL_23 BL[0]_23 BL[1]_23 BL[2]_23 BL[3]_23 CORED00_144 CORED01_146
+  CORED10_148 CORED11_150 CORED20_152 CORED21_154 CORED30_156 CORED31_158
+  NBL[0]_23 NBL[1]_23 NBL[2]_23 NBL[3]_23 NCORED00_160 NCORED01_162
+  NCORED10_164 NCORED11_166 NCORED20_168 NCORED21_170 NCORED30_172
+  NCORED31_174 VDDC_23 VDDCE_23 VDDPE_23 VNWC_24 VPW_24 VPW_0 WL[0] WL[1]
+  sram464x144CCHD4
XMEM_R_COL_24 BL[0]_24 BL[1]_24 BL[2]_24 BL[3]_24 CORED00_176 CORED01_178
+  CORED10_180 CORED11_182 CORED20_184 CORED21_186 CORED30_188 CORED31_190
+  NBL[0]_24 NBL[1]_24 NBL[2]_24 NBL[3]_24 NCORED00_192 NCORED01_194
+  NCORED10_196 NCORED11_198 NCORED20_200 NCORED21_202 NCORED30_204
+  NCORED31_206 VDDC_24 VDDCE_24 VDDPE_24 VNWC_25 VPW_25 VPW_0 WL[0] WL[1]
+  sram464x144CCHD4
XMEM_R_COL_25 BL[0]_25 BL[1]_25 BL[2]_25 BL[3]_25 CORED00_208 CORED01_210
+  CORED10_212 CORED11_214 CORED20_216 CORED21_218 CORED30_220 CORED31_222
+  NBL[0]_25 NBL[1]_25 NBL[2]_25 NBL[3]_25 NCORED00_224 NCORED01_226
+  NCORED10_228 NCORED11_230 NCORED20_232 NCORED21_234 NCORED30_236
+  NCORED31_238 VDDC_25 VDDCE_25 VDDPE_25 VNWC_26 VPW_26 VPW_0 WL[0] WL[1]
+  sram464x144CCHD4
XMEM_R_COL_26 BL[0]_26 BL[1]_26 BL[2]_26 BL[3]_26 CORED00_240 CORED01_242
+  CORED10_244 CORED11_246 CORED20_248 CORED21_250 CORED30_252 CORED31_254
+  NBL[0]_26 NBL[1]_26 NBL[2]_26 NBL[3]_26 NCORED00_256 NCORED01_258
+  NCORED10_260 NCORED11_262 NCORED20_264 NCORED21_266 NCORED30_268
+  NCORED31_270 VDDC_26 VDDCE_26 VDDPE_26 VNWC_27 VPW_27 VPW_0 WL[0] WL[1]
+  sram464x144CCHD4
XMEM_R_COL_27 BL[0]_27 BL[1]_27 BL[2]_27 BL[3]_27 CORED00_272 CORED01_274
+  CORED10_276 CORED11_278 CORED20_280 CORED21_282 CORED30_284 CORED31_286
+  NBL[0]_27 NBL[1]_27 NBL[2]_27 NBL[3]_27 NCORED00_288 NCORED01_290
+  NCORED10_292 NCORED11_294 NCORED20_296 NCORED21_298 NCORED30_300
+  NCORED31_302 VDDC_27 VDDCE_27 VDDPE_27 VNWC_28 VPW_28 VPW_0 WL[0] WL[1]
+  sram464x144CCHD4
XMEM_R_COL_28 BL[0]_28 BL[1]_28 BL[2]_28 BL[3]_28 CORED00_304 CORED01_306
+  CORED10_308 CORED11_310 CORED20_312 CORED21_314 CORED30_316 CORED31_318
+  NBL[0]_28 NBL[1]_28 NBL[2]_28 NBL[3]_28 NCORED00_320 NCORED01_322
+  NCORED10_324 NCORED11_326 NCORED20_328 NCORED21_330 NCORED30_332
+  NCORED31_334 VDDC_28 VDDCE_28 VDDPE_28 VNWC_29 VPW_29 VPW_0 WL[0] WL[1]
+  sram464x144CCHD4
XMEM_R_COL_29 BL[0]_29 BL[1]_29 BL[2]_29 BL[3]_29 CORED00_336 CORED01_338
+  CORED10_340 CORED11_342 CORED20_344 CORED21_346 CORED30_348 CORED31_350
+  NBL[0]_29 NBL[1]_29 NBL[2]_29 NBL[3]_29 NCORED00_352 NCORED01_354
+  NCORED10_356 NCORED11_358 NCORED20_360 NCORED21_362 NCORED30_364
+  NCORED31_366 VDDC_29 VDDCE_29 VDDPE_29 VNWC_30 VPW_30 VPW_0 WL[0] WL[1]
+  sram464x144CCHD4
XMEM_R_COL_3 BL[0]_3 BL[1]_3 BL[2]_3 BL[3]_3 CORED00_432 CORED01_434
+  CORED10_436 CORED11_438 CORED20_440 CORED21_442 CORED30_444 CORED31_446
+  NBL[0]_3 NBL[1]_3 NBL[2]_3 NBL[3]_3 NCORED00_448 NCORED01_450 NCORED10_452
+  NCORED11_454 NCORED20_456 NCORED21_458 NCORED30_460 NCORED31_462 VDDC_3
+  VDDCE_3 VDDPE_3 VNWC_4 VPW_4 VPW_0 WL[0] WL[1] sram464x144CCHD4
XMEM_R_COL_30 BL[0]_30 BL[1]_30 BL[2]_30 BL[3]_30 CORED00_752 CORED01_754
+  CORED10_756 CORED11_758 CORED20_760 CORED21_762 CORED30_764 CORED31_766
+  NBL[0]_30 NBL[1]_30 NBL[2]_30 NBL[3]_30 NCORED00_768 NCORED01_770
+  NCORED10_772 NCORED11_774 NCORED20_776 NCORED21_778 NCORED30_780
+  NCORED31_782 VDDC_30 VDDCE_30 VDDPE_30 VNWC_31 VPW_31 VPW_0 WL[0] WL[1]
+  sram464x144CCHD4
XMEM_R_COL_31 BL[0]_31 BL[1]_31 BL[2]_31 BL[3]_31 CORED00_784 CORED01_786
+  CORED10_788 CORED11_790 CORED20_792 CORED21_794 CORED30_796 CORED31_798
+  NBL[0]_31 NBL[1]_31 NBL[2]_31 NBL[3]_31 NCORED00_800 NCORED01_802
+  NCORED10_804 NCORED11_806 NCORED20_808 NCORED21_810 NCORED30_812
+  NCORED31_814 VDDC_31 VDDCE_31 VDDPE_31 VNWC_32 VPW_32 VPW_0 WL[0] WL[1]
+  sram464x144CCHD4
XMEM_R_COL_32 BL[0]_32 BL[1]_32 BL[2]_32 BL[3]_32 CORED00_848 CORED01_850
+  CORED10_852 CORED11_854 CORED20_856 CORED21_858 CORED30_860 CORED31_862
+  NBL[0]_32 NBL[1]_32 NBL[2]_32 NBL[3]_32 NCORED00_864 NCORED01_866
+  NCORED10_868 NCORED11_870 NCORED20_872 NCORED21_874 NCORED30_876
+  NCORED31_878 VDDC_32 VDDCE_32 VDDPE_32 VNWC_33 VPW_33 VPW_0 WL[0] WL[1]
+  sram464x144CCHD4
XMEM_R_COL_33 BL[0]_33 BL[1]_33 BL[2]_33 BL[3]_33 CORED00_912 CORED01_914
+  CORED10_916 CORED11_918 CORED20_920 CORED21_922 CORED30_924 CORED31_926
+  NBL[0]_33 NBL[1]_33 NBL[2]_33 NBL[3]_33 NCORED00_928 NCORED01_930
+  NCORED10_932 NCORED11_934 NCORED20_936 NCORED21_938 NCORED30_940
+  NCORED31_942 VDDC_33 VDDCE_33 VDDPE_33 VNWC_34 VPW_34 VPW_0 WL[0] WL[1]
+  sram464x144CCHD4
XMEM_R_COL_34 BL[0]_34 BL[1]_34 BL[2]_34 BL[3]_34 CORED00_976 CORED01_978
+  CORED10_980 CORED11_982 CORED20_984 CORED21_986 CORED30_988 CORED31_990
+  NBL[0]_34 NBL[1]_34 NBL[2]_34 NBL[3]_34 NCORED00_992 NCORED01_994
+  NCORED10_996 NCORED11_998 NCORED20_1000 NCORED21_1002 NCORED30_1004
+  NCORED31_1006 VDDC_34 VDDCE_34 VDDPE_34 VNWC_35 VPW_35 VPW_0 WL[0] WL[1]
+  sram464x144CCHD4
XMEM_R_COL_4 BL[0]_4 BL[1]_4 BL[2]_4 BL[3]_4 CORED00_464 CORED01_466
+  CORED10_468 CORED11_470 CORED20_472 CORED21_474 CORED30_476 CORED31_478
+  NBL[0]_4 NBL[1]_4 NBL[2]_4 NBL[3]_4 NCORED00_480 NCORED01_482 NCORED10_484
+  NCORED11_486 NCORED20_488 NCORED21_490 NCORED30_492 NCORED31_494 VDDC_4
+  VDDCE_4 VDDPE_4 VNWC_5 VPW_5 VPW_0 WL[0] WL[1] sram464x144CCHD4
XMEM_R_COL_5 BL[0]_5 BL[1]_5 BL[2]_5 BL[3]_5 CORED00_496 CORED01_498
+  CORED10_500 CORED11_502 CORED20_504 CORED21_506 CORED30_508 CORED31_510
+  NBL[0]_5 NBL[1]_5 NBL[2]_5 NBL[3]_5 NCORED00_512 NCORED01_514 NCORED10_516
+  NCORED11_518 NCORED20_520 NCORED21_522 NCORED30_524 NCORED31_526 VDDC_5
+  VDDCE_5 VDDPE_5 VNWC_6 VPW_6 VPW_0 WL[0] WL[1] sram464x144CCHD4
XMEM_R_COL_6 BL[0]_6 BL[1]_6 BL[2]_6 BL[3]_6 CORED00_528 CORED01_530
+  CORED10_532 CORED11_534 CORED20_536 CORED21_538 CORED30_540 CORED31_542
+  NBL[0]_6 NBL[1]_6 NBL[2]_6 NBL[3]_6 NCORED00_544 NCORED01_546 NCORED10_548
+  NCORED11_550 NCORED20_552 NCORED21_554 NCORED30_556 NCORED31_558 VDDC_6
+  VDDCE_6 VDDPE_6 VNWC_7 VPW_7 VPW_0 WL[0] WL[1] sram464x144CCHD4
XMEM_R_COL_7 BL[0]_7 BL[1]_7 BL[2]_7 BL[3]_7 CORED00_560 CORED01_562
+  CORED10_564 CORED11_566 CORED20_568 CORED21_570 CORED30_572 CORED31_574
+  NBL[0]_7 NBL[1]_7 NBL[2]_7 NBL[3]_7 NCORED00_576 NCORED01_578 NCORED10_580
+  NCORED11_582 NCORED20_584 NCORED21_586 NCORED30_588 NCORED31_590 VDDC_7
+  VDDCE_7 VDDPE_7 VNWC_8 VPW_8 VPW_0 WL[0] WL[1] sram464x144CCHD4
XMEM_R_COL_8 BL[0]_8 BL[1]_8 BL[2]_8 BL[3]_8 CORED00_592 CORED01_594
+  CORED10_596 CORED11_598 CORED20_600 CORED21_602 CORED30_604 CORED31_606
+  NBL[0]_8 NBL[1]_8 NBL[2]_8 NBL[3]_8 NCORED00_608 NCORED01_610 NCORED10_612
+  NCORED11_614 NCORED20_616 NCORED21_618 NCORED30_620 NCORED31_622 VDDC_8
+  VDDCE_8 VDDPE_8 VNWC_9 VPW_9 VPW_0 WL[0] WL[1] sram464x144CCHD4
XMEM_R_COL_9 BL[0]_9 BL[1]_9 BL[2]_9 BL[3]_9 CORED00_624 CORED01_626
+  CORED10_628 CORED11_630 CORED20_632 CORED21_634 CORED30_636 CORED31_638
+  NBL[0]_9 NBL[1]_9 NBL[2]_9 NBL[3]_9 NCORED00_640 NCORED01_642 NCORED10_644
+  NCORED11_646 NCORED20_648 NCORED21_650 NCORED30_652 NCORED31_654 VDDC_9
+  VDDCE_9 VDDPE_9 VNWC_10 VPW_10 VPW_0 WL[0] WL[1] sram464x144CCHD4
XMEM_R_COL_EDGEL VNWC_0 VNWP_0 VPW_0 VPW_0 WL[0] WL[1] sram464x144CCHD4WD_EDG
XMEM_R_COL_EDGER VNWC_37 VNWP_1 VPW_0 VPW_0 WL[0] WL[1] sram464x144CCHD4_EDG
XMEM_R_COL_TOP_L BL[0]_0 BL[1]_0 BL[2]_0 BL[3]_0 CORED00 CORED01 CORED10
+  CORED11 CORED20 CORED21 CORED30 CORED31 NBL[0]_0 NBL[1]_0 NBL[2]_0 NBL[3]_0
+  NCORED00 NCORED01 NCORED10 NCORED11 NCORED20 NCORED21 NCORED30 NCORED31
+  VDDC_0 VDDCE_0 VDDPE_0 VNWC_1 VPW_1 VPW_0 WL[0] WL[1] sram464x144CCHD4
XMEM_R_COL_TOP_R BL[0]_35 BL[1]_35 BL[2]_35 BL[3]_35 CORED00_80 CORED01_82
+  CORED10_84 CORED11_86 CORED20_88 CORED21_90 CORED30_92 CORED31_94 NBL[0]_35
+  NBL[1]_35 NBL[2]_35 NBL[3]_35 NCORED00_96 NCORED01_98 NCORED10_100
+  NCORED11_102 NCORED20_104 NCORED21_106 NCORED30_108 NCORED31_110 VDDC_35
+  VDDCE_35 VDDPE_35 VNWC_36 VPW_36 VPW_0 WL[0] WL[1] sram464x144CCHD4
.ENDS sram464x144MEM_R_TOP_ROW
****
.SUBCKT sram464x144MEMCORE_R BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5
+  BL[0]_6 BL[0]_7 BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13
+  BL[0]_14 BL[0]_15 BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21
+  BL[0]_22 BL[0]_23 BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29
+  BL[0]_30 BL[0]_31 BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1
+  BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10
+  BL[1]_11 BL[1]_12 BL[1]_13 BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18
+  BL[1]_19 BL[1]_20 BL[1]_21 BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26
+  BL[1]_27 BL[1]_28 BL[1]_29 BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34
+  BL[1]_35 BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7
+  BL[2]_8 BL[2]_9 BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15
+  BL[2]_16 BL[2]_17 BL[2]_18 BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23
+  BL[2]_24 BL[2]_25 BL[2]_26 BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31
+  BL[2]_32 BL[2]_33 BL[2]_34 BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4
+  BL[3]_5 BL[3]_6 BL[3]_7 BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13
+  BL[3]_14 BL[3]_15 BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21
+  BL[3]_22 BL[3]_23 BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29
+  BL[3]_30 BL[3]_31 BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1
+  NBL[0]_2 NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9
+  NBL[0]_10 NBL[0]_11 NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16
+  NBL[0]_17 NBL[0]_18 NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23
+  NBL[0]_24 NBL[0]_25 NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30
+  NBL[0]_31 NBL[0]_32 NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1
+  NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9
+  NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16
+  NBL[1]_17 NBL[1]_18 NBL[1]_19 NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23
+  NBL[1]_24 NBL[1]_25 NBL[1]_26 NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30
+  NBL[1]_31 NBL[1]_32 NBL[1]_33 NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1
+  NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9
+  NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13 NBL[2]_14 NBL[2]_15 NBL[2]_16
+  NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20 NBL[2]_21 NBL[2]_22 NBL[2]_23
+  NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27 NBL[2]_28 NBL[2]_29 NBL[2]_30
+  NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34 NBL[2]_35 NBL[3]_0 NBL[3]_1
+  NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 NBL[3]_8 NBL[3]_9
+  NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13 NBL[3]_14 NBL[3]_15 NBL[3]_16
+  NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20 NBL[3]_21 NBL[3]_22 NBL[3]_23
+  NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27 NBL[3]_28 NBL[3]_29 NBL[3]_30
+  NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34 NBL[3]_35 VDDC VDDPE_0 VDDPE_1
+  VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8 VDDPE_9 VDDPE_10
+  VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16 VDDPE_17 VDDPE_18
+  VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24 VDDPE_25 VDDPE_26
+  VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32 VDDPE_33 VDDPE_34
+  VDDPE_35 VNWP_0 VNWP_1 VPW WL[0]_0 WL[0]_1 WL[0]_2 WL[0]_3 WL[0]_4 WL[0]_5
+  WL[0]_6 WL[0]_7 WL[0]_8 WL[0]_9 WL[0]_10 WL[0]_11 WL[0]_12 WL[0]_13
+  WL[0]_14 WL[0]_15 WL[0]_16 WL[0]_17 WL[0]_18 WL[0]_19 WL[0]_20 WL[0]_21
+  WL[0]_22 WL[0]_23 WL[0]_24 WL[0]_25 WL[0]_26 WL[0]_27 WL[0]_28 WL[0]_29
+  WL[0]_30 WL[0]_31 WL[0]_32 WL[0]_33 WL[0]_34 WL[0]_35 WL[0]_36 WL[0]_37
+  WL[0]_38 WL[0]_39 WL[0]_40 WL[0]_41 WL[0]_42 WL[0]_43 WL[0]_44 WL[0]_45
+  WL[0]_46 WL[0]_47 WL[0]_48 WL[0]_49 WL[0]_50 WL[0]_51 WL[0]_52 WL[0]_53
+  WL[0]_54 WL[0]_55 WL[0]_56 WL[0]_57 WL[0]_58 WL[0]_59 WL[0]_60 WL[0]_61
+  WL[0]_62 WL[0]_63 WL[0]_64 WL[0]_65 WL[0]_66 WL[0]_67 WL[0]_68 WL[0]_69
+  WL[0]_70 WL[0]_71 WL[0]_72 WL[0]_73 WL[0]_74 WL[0]_75 WL[0]_76 WL[0]_77
+  WL[0]_78 WL[0]_79 WL[0]_80 WL[0]_81 WL[0]_82 WL[0]_83 WL[0]_84 WL[0]_85
+  WL[0]_86 WL[0]_87 WL[0]_88 WL[0]_89 WL[0]_90 WL[0]_91 WL[0]_92 WL[0]_93
+  WL[0]_94 WL[0]_95 WL[0]_96 WL[0]_97 WL[0]_98 WL[0]_99 WL[0]_100 WL[0]_101
+  WL[0]_102 WL[0]_103 WL[0]_104 WL[0]_105 WL[0]_106 WL[0]_107 WL[0]_108
+  WL[0]_109 WL[0]_110 WL[0]_111 WL[0]_112 WL[0]_113 WL[0]_114 WL[0]_115
+  WL[1]_0 WL[1]_1 WL[1]_2 WL[1]_3 WL[1]_4 WL[1]_5 WL[1]_6 WL[1]_7 WL[1]_8
+  WL[1]_9 WL[1]_10 WL[1]_11 WL[1]_12 WL[1]_13 WL[1]_14 WL[1]_15 WL[1]_16
+  WL[1]_17 WL[1]_18 WL[1]_19 WL[1]_20 WL[1]_21 WL[1]_22 WL[1]_23 WL[1]_24
+  WL[1]_25 WL[1]_26 WL[1]_27 WL[1]_28 WL[1]_29 WL[1]_30 WL[1]_31 WL[1]_32
+  WL[1]_33 WL[1]_34 WL[1]_35 WL[1]_36 WL[1]_37 WL[1]_38 WL[1]_39 WL[1]_40
+  WL[1]_41 WL[1]_42 WL[1]_43 WL[1]_44 WL[1]_45 WL[1]_46 WL[1]_47 WL[1]_48
+  WL[1]_49 WL[1]_50 WL[1]_51 WL[1]_52 WL[1]_53 WL[1]_54 WL[1]_55 WL[1]_56
+  WL[1]_57 WL[1]_58 WL[1]_59 WL[1]_60 WL[1]_61 WL[1]_62 WL[1]_63 WL[1]_64
+  WL[1]_65 WL[1]_66 WL[1]_67 WL[1]_68 WL[1]_69 WL[1]_70 WL[1]_71 WL[1]_72
+  WL[1]_73 WL[1]_74 WL[1]_75 WL[1]_76 WL[1]_77 WL[1]_78 WL[1]_79 WL[1]_80
+  WL[1]_81 WL[1]_82 WL[1]_83 WL[1]_84 WL[1]_85 WL[1]_86 WL[1]_87 WL[1]_88
+  WL[1]_89 WL[1]_90 WL[1]_91 WL[1]_92 WL[1]_93 WL[1]_94 WL[1]_95 WL[1]_96
+  WL[1]_97 WL[1]_98 WL[1]_99 WL[1]_100 WL[1]_101 WL[1]_102 WL[1]_103
+  WL[1]_104 WL[1]_105 WL[1]_106 WL[1]_107 WL[1]_108 WL[1]_109 WL[1]_110
+  WL[1]_111 WL[1]_112 WL[1]_113 WL[1]_114 WL[1]_115
** sram464x144MEMCORE_R: 202938 flat devices **
XMEM_R_ROW_1 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW WL[0]_1 WL[1]_1 sram464x144MEM_R_ROW
XMEM_R_ROW_10 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW WL[0]_10 WL[1]_10 sram464x144MEM_R_ROW
XMEM_R_ROW_100 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW WL[0]_100 WL[1]_100 sram464x144MEM_R_ROW
XMEM_R_ROW_101 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW WL[0]_101 WL[1]_101 sram464x144MEM_R_ROW
XMEM_R_ROW_102 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW WL[0]_102 WL[1]_102 sram464x144MEM_R_ROW
XMEM_R_ROW_103 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW WL[0]_103 WL[1]_103 sram464x144MEM_R_ROW
XMEM_R_ROW_104 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW WL[0]_104 WL[1]_104 sram464x144MEM_R_ROW
XMEM_R_ROW_105 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW WL[0]_105 WL[1]_105 sram464x144MEM_R_ROW
XMEM_R_ROW_106 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW WL[0]_106 WL[1]_106 sram464x144MEM_R_ROW
XMEM_R_ROW_107 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW WL[0]_107 WL[1]_107 sram464x144MEM_R_ROW
XMEM_R_ROW_108 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW WL[0]_108 WL[1]_108 sram464x144MEM_R_ROW
XMEM_R_ROW_109 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW WL[0]_109 WL[1]_109 sram464x144MEM_R_ROW
XMEM_R_ROW_11 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW WL[0]_11 WL[1]_11 sram464x144MEM_R_ROW
XMEM_R_ROW_110 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW WL[0]_110 WL[1]_110 sram464x144MEM_R_ROW
XMEM_R_ROW_111 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW WL[0]_111 WL[1]_111 sram464x144MEM_R_ROW
XMEM_R_ROW_112 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW WL[0]_112 WL[1]_112 sram464x144MEM_R_ROW
XMEM_R_ROW_113 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW WL[0]_113 WL[1]_113 sram464x144MEM_R_ROW
XMEM_R_ROW_114 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW WL[0]_114 WL[1]_114 sram464x144MEM_R_ROW
XMEM_R_ROW_12 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW WL[0]_12 WL[1]_12 sram464x144MEM_R_ROW
XMEM_R_ROW_13 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW WL[0]_13 WL[1]_13 sram464x144MEM_R_ROW
XMEM_R_ROW_14 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW WL[0]_14 WL[1]_14 sram464x144MEM_R_ROW
XMEM_R_ROW_15 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW WL[0]_15 WL[1]_15 sram464x144MEM_R_ROW
XMEM_R_ROW_16 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW WL[0]_16 WL[1]_16 sram464x144MEM_R_ROW
XMEM_R_ROW_17 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW WL[0]_17 WL[1]_17 sram464x144MEM_R_ROW
XMEM_R_ROW_18 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW WL[0]_18 WL[1]_18 sram464x144MEM_R_ROW
XMEM_R_ROW_19 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW WL[0]_19 WL[1]_19 sram464x144MEM_R_ROW
XMEM_R_ROW_2 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW WL[0]_2 WL[1]_2 sram464x144MEM_R_ROW
XMEM_R_ROW_20 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW WL[0]_20 WL[1]_20 sram464x144MEM_R_ROW
XMEM_R_ROW_21 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW WL[0]_21 WL[1]_21 sram464x144MEM_R_ROW
XMEM_R_ROW_22 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW WL[0]_22 WL[1]_22 sram464x144MEM_R_ROW
XMEM_R_ROW_23 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW WL[0]_23 WL[1]_23 sram464x144MEM_R_ROW
XMEM_R_ROW_24 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW WL[0]_24 WL[1]_24 sram464x144MEM_R_ROW
XMEM_R_ROW_25 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW WL[0]_25 WL[1]_25 sram464x144MEM_R_ROW
XMEM_R_ROW_26 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW WL[0]_26 WL[1]_26 sram464x144MEM_R_ROW
XMEM_R_ROW_27 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW WL[0]_27 WL[1]_27 sram464x144MEM_R_ROW
XMEM_R_ROW_28 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW WL[0]_28 WL[1]_28 sram464x144MEM_R_ROW
XMEM_R_ROW_29 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW WL[0]_29 WL[1]_29 sram464x144MEM_R_ROW
XMEM_R_ROW_3 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW WL[0]_3 WL[1]_3 sram464x144MEM_R_ROW
XMEM_R_ROW_30 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW WL[0]_30 WL[1]_30 sram464x144MEM_R_ROW
XMEM_R_ROW_31 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW WL[0]_31 WL[1]_31 sram464x144MEM_R_ROW
XMEM_R_ROW_32 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW WL[0]_32 WL[1]_32 sram464x144MEM_R_ROW
XMEM_R_ROW_33 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW WL[0]_33 WL[1]_33 sram464x144MEM_R_ROW
XMEM_R_ROW_34 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW WL[0]_34 WL[1]_34 sram464x144MEM_R_ROW
XMEM_R_ROW_35 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW WL[0]_35 WL[1]_35 sram464x144MEM_R_ROW
XMEM_R_ROW_36 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW WL[0]_36 WL[1]_36 sram464x144MEM_R_ROW
XMEM_R_ROW_37 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW WL[0]_37 WL[1]_37 sram464x144MEM_R_ROW
XMEM_R_ROW_38 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW WL[0]_38 WL[1]_38 sram464x144MEM_R_ROW
XMEM_R_ROW_39 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW WL[0]_39 WL[1]_39 sram464x144MEM_R_ROW
XMEM_R_ROW_4 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW WL[0]_4 WL[1]_4 sram464x144MEM_R_ROW
XMEM_R_ROW_40 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW WL[0]_40 WL[1]_40 sram464x144MEM_R_ROW
XMEM_R_ROW_41 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW WL[0]_41 WL[1]_41 sram464x144MEM_R_ROW
XMEM_R_ROW_42 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW WL[0]_42 WL[1]_42 sram464x144MEM_R_ROW
XMEM_R_ROW_43 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW WL[0]_43 WL[1]_43 sram464x144MEM_R_ROW
XMEM_R_ROW_44 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW WL[0]_44 WL[1]_44 sram464x144MEM_R_ROW
XMEM_R_ROW_45 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW WL[0]_45 WL[1]_45 sram464x144MEM_R_ROW
XMEM_R_ROW_46 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW WL[0]_46 WL[1]_46 sram464x144MEM_R_ROW
XMEM_R_ROW_47 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW WL[0]_47 WL[1]_47 sram464x144MEM_R_ROW
XMEM_R_ROW_48 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW WL[0]_48 WL[1]_48 sram464x144MEM_R_ROW
XMEM_R_ROW_49 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW WL[0]_49 WL[1]_49 sram464x144MEM_R_ROW
XMEM_R_ROW_5 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW WL[0]_5 WL[1]_5 sram464x144MEM_R_ROW
XMEM_R_ROW_50 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW WL[0]_50 WL[1]_50 sram464x144MEM_R_ROW
XMEM_R_ROW_51 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW WL[0]_51 WL[1]_51 sram464x144MEM_R_ROW
XMEM_R_ROW_52 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW WL[0]_52 WL[1]_52 sram464x144MEM_R_ROW
XMEM_R_ROW_53 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW WL[0]_53 WL[1]_53 sram464x144MEM_R_ROW
XMEM_R_ROW_54 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW WL[0]_54 WL[1]_54 sram464x144MEM_R_ROW
XMEM_R_ROW_55 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW WL[0]_55 WL[1]_55 sram464x144MEM_R_ROW
XMEM_R_ROW_59 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW WL[0]_59 WL[1]_59 sram464x144MEM_R_ROW
XMEM_R_ROW_6 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW WL[0]_6 WL[1]_6 sram464x144MEM_R_ROW
XMEM_R_ROW_60 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW WL[0]_60 WL[1]_60 sram464x144MEM_R_ROW
XMEM_R_ROW_61 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW WL[0]_61 WL[1]_61 sram464x144MEM_R_ROW
XMEM_R_ROW_62 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW WL[0]_62 WL[1]_62 sram464x144MEM_R_ROW
XMEM_R_ROW_63 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW WL[0]_63 WL[1]_63 sram464x144MEM_R_ROW
XMEM_R_ROW_64 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW WL[0]_64 WL[1]_64 sram464x144MEM_R_ROW
XMEM_R_ROW_65 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW WL[0]_65 WL[1]_65 sram464x144MEM_R_ROW
XMEM_R_ROW_66 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW WL[0]_66 WL[1]_66 sram464x144MEM_R_ROW
XMEM_R_ROW_67 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW WL[0]_67 WL[1]_67 sram464x144MEM_R_ROW
XMEM_R_ROW_68 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW WL[0]_68 WL[1]_68 sram464x144MEM_R_ROW
XMEM_R_ROW_69 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW WL[0]_69 WL[1]_69 sram464x144MEM_R_ROW
XMEM_R_ROW_7 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW WL[0]_7 WL[1]_7 sram464x144MEM_R_ROW
XMEM_R_ROW_70 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW WL[0]_70 WL[1]_70 sram464x144MEM_R_ROW
XMEM_R_ROW_71 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW WL[0]_71 WL[1]_71 sram464x144MEM_R_ROW
XMEM_R_ROW_72 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW WL[0]_72 WL[1]_72 sram464x144MEM_R_ROW
XMEM_R_ROW_73 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW WL[0]_73 WL[1]_73 sram464x144MEM_R_ROW
XMEM_R_ROW_74 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW WL[0]_74 WL[1]_74 sram464x144MEM_R_ROW
XMEM_R_ROW_75 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW WL[0]_75 WL[1]_75 sram464x144MEM_R_ROW
XMEM_R_ROW_76 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW WL[0]_76 WL[1]_76 sram464x144MEM_R_ROW
XMEM_R_ROW_77 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW WL[0]_77 WL[1]_77 sram464x144MEM_R_ROW
XMEM_R_ROW_78 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW WL[0]_78 WL[1]_78 sram464x144MEM_R_ROW
XMEM_R_ROW_79 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW WL[0]_79 WL[1]_79 sram464x144MEM_R_ROW
XMEM_R_ROW_8 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW WL[0]_8 WL[1]_8 sram464x144MEM_R_ROW
XMEM_R_ROW_80 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW WL[0]_80 WL[1]_80 sram464x144MEM_R_ROW
XMEM_R_ROW_81 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW WL[0]_81 WL[1]_81 sram464x144MEM_R_ROW
XMEM_R_ROW_82 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW WL[0]_82 WL[1]_82 sram464x144MEM_R_ROW
XMEM_R_ROW_83 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW WL[0]_83 WL[1]_83 sram464x144MEM_R_ROW
XMEM_R_ROW_84 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW WL[0]_84 WL[1]_84 sram464x144MEM_R_ROW
XMEM_R_ROW_85 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW WL[0]_85 WL[1]_85 sram464x144MEM_R_ROW
XMEM_R_ROW_86 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW WL[0]_86 WL[1]_86 sram464x144MEM_R_ROW
XMEM_R_ROW_87 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW WL[0]_87 WL[1]_87 sram464x144MEM_R_ROW
XMEM_R_ROW_88 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW WL[0]_88 WL[1]_88 sram464x144MEM_R_ROW
XMEM_R_ROW_89 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW WL[0]_89 WL[1]_89 sram464x144MEM_R_ROW
XMEM_R_ROW_9 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW WL[0]_9 WL[1]_9 sram464x144MEM_R_ROW
XMEM_R_ROW_90 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW WL[0]_90 WL[1]_90 sram464x144MEM_R_ROW
XMEM_R_ROW_91 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW WL[0]_91 WL[1]_91 sram464x144MEM_R_ROW
XMEM_R_ROW_92 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW WL[0]_92 WL[1]_92 sram464x144MEM_R_ROW
XMEM_R_ROW_93 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW WL[0]_93 WL[1]_93 sram464x144MEM_R_ROW
XMEM_R_ROW_94 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW WL[0]_94 WL[1]_94 sram464x144MEM_R_ROW
XMEM_R_ROW_95 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW WL[0]_95 WL[1]_95 sram464x144MEM_R_ROW
XMEM_R_ROW_96 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW WL[0]_96 WL[1]_96 sram464x144MEM_R_ROW
XMEM_R_ROW_97 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW WL[0]_97 WL[1]_97 sram464x144MEM_R_ROW
XMEM_R_ROW_98 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW WL[0]_98 WL[1]_98 sram464x144MEM_R_ROW
XMEM_R_ROW_99 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW WL[0]_99 WL[1]_99 sram464x144MEM_R_ROW
XMEM_R_ROW_BOT BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW WL[0]_0 WL[1]_0 sram464x144MEM_R_BOT_ROW
XMEM_R_ROW_CAP BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7
+  VDDPE_8 VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15
+  VDDPE_16 VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23
+  VDDPE_24 VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31
+  VDDPE_32 VDDPE_33 VDDPE_34 VDDPE_35 VDDC VNWP_0 VNWP_1 VPW
+  sram464x144MEM_SLICE_CAP_R
XMEM_R_ROW_MID BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW WL[0]_57 WL[1]_57 sram464x144MEM_R_MID_ROW
XMEM_R_ROW_MIDB BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6
+  BL[0]_7 BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14
+  BL[0]_15 BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22
+  BL[0]_23 BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30
+  BL[0]_31 BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2
+  BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11
+  BL[1]_12 BL[1]_13 BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19
+  BL[1]_20 BL[1]_21 BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27
+  BL[1]_28 BL[1]_29 BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35
+  BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8
+  BL[2]_9 BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16
+  BL[2]_17 BL[2]_18 BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24
+  BL[2]_25 BL[2]_26 BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32
+  BL[2]_33 BL[2]_34 BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5
+  BL[3]_6 BL[3]_7 BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13
+  BL[3]_14 BL[3]_15 BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21
+  BL[3]_22 BL[3]_23 BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29
+  BL[3]_30 BL[3]_31 BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1
+  NBL[0]_2 NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9
+  NBL[0]_10 NBL[0]_11 NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16
+  NBL[0]_17 NBL[0]_18 NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23
+  NBL[0]_24 NBL[0]_25 NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30
+  NBL[0]_31 NBL[0]_32 NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1
+  NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9
+  NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16
+  NBL[1]_17 NBL[1]_18 NBL[1]_19 NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23
+  NBL[1]_24 NBL[1]_25 NBL[1]_26 NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30
+  NBL[1]_31 NBL[1]_32 NBL[1]_33 NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1
+  NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9
+  NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13 NBL[2]_14 NBL[2]_15 NBL[2]_16
+  NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20 NBL[2]_21 NBL[2]_22 NBL[2]_23
+  NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27 NBL[2]_28 NBL[2]_29 NBL[2]_30
+  NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34 NBL[2]_35 NBL[3]_0 NBL[3]_1
+  NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 NBL[3]_8 NBL[3]_9
+  NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13 NBL[3]_14 NBL[3]_15 NBL[3]_16
+  NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20 NBL[3]_21 NBL[3]_22 NBL[3]_23
+  NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27 NBL[3]_28 NBL[3]_29 NBL[3]_30
+  NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34 NBL[3]_35 VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4
+  VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8 VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13
+  VDDPE_14 VDDPE_15 VDDPE_16 VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21
+  VDDPE_22 VDDPE_23 VDDPE_24 VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29
+  VDDPE_30 VDDPE_31 VDDPE_32 VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW VPW VPW VPW VPW VPW WL[0]_56 WL[1]_56 sram464x144MEM_R_MIDB_ROW
XMEM_R_ROW_MIDT BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6
+  BL[0]_7 BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14
+  BL[0]_15 BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22
+  BL[0]_23 BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30
+  BL[0]_31 BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2
+  BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11
+  BL[1]_12 BL[1]_13 BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19
+  BL[1]_20 BL[1]_21 BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27
+  BL[1]_28 BL[1]_29 BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35
+  BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8
+  BL[2]_9 BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16
+  BL[2]_17 BL[2]_18 BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24
+  BL[2]_25 BL[2]_26 BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32
+  BL[2]_33 BL[2]_34 BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5
+  BL[3]_6 BL[3]_7 BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13
+  BL[3]_14 BL[3]_15 BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21
+  BL[3]_22 BL[3]_23 BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29
+  BL[3]_30 BL[3]_31 BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1
+  NBL[0]_2 NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9
+  NBL[0]_10 NBL[0]_11 NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16
+  NBL[0]_17 NBL[0]_18 NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23
+  NBL[0]_24 NBL[0]_25 NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30
+  NBL[0]_31 NBL[0]_32 NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1
+  NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9
+  NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16
+  NBL[1]_17 NBL[1]_18 NBL[1]_19 NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23
+  NBL[1]_24 NBL[1]_25 NBL[1]_26 NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30
+  NBL[1]_31 NBL[1]_32 NBL[1]_33 NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1
+  NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9
+  NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13 NBL[2]_14 NBL[2]_15 NBL[2]_16
+  NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20 NBL[2]_21 NBL[2]_22 NBL[2]_23
+  NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27 NBL[2]_28 NBL[2]_29 NBL[2]_30
+  NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34 NBL[2]_35 NBL[3]_0 NBL[3]_1
+  NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 NBL[3]_8 NBL[3]_9
+  NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13 NBL[3]_14 NBL[3]_15 NBL[3]_16
+  NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20 NBL[3]_21 NBL[3]_22 NBL[3]_23
+  NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27 NBL[3]_28 NBL[3]_29 NBL[3]_30
+  NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34 NBL[3]_35 VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4
+  VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8 VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13
+  VDDPE_14 VDDPE_15 VDDPE_16 VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21
+  VDDPE_22 VDDPE_23 VDDPE_24 VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29
+  VDDPE_30 VDDPE_31 VDDPE_32 VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW VPW VPW VPW VPW VPW WL[0]_58 WL[1]_58 sram464x144MEM_R_MIDT_ROW
XMEM_R_ROW_TOP BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8
+  VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16
+  VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24
+  VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32
+  VDDPE_33 VDDPE_34 VDDPE_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VNWP_0 VNWP_1 VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW WL[0]_115 WL[1]_115 sram464x144MEM_R_TOP_ROW
XMEM_R_STRAP0 BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC
+  VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3
+  VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8 VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12
+  VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16 VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20
+  VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24 VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28
+  VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32 VDDPE_33 VDDPE_34 VDDPE_35 VDDC VNWP_0
+  VNWP_1 VPW sram464x144MEM_R_STRAPROW
.ENDS sram464x144MEMCORE_R
****
.SUBCKT sram464x144WDX2 ACTP DBL G0 G1 INI0 INI1 LOG0_DWL NACTC NI0 NI1 NI2
+  NI3 NI4 NI5 NI6 NI7 NRETNVT NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5
+  NXP0_6 NXP0_7 NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 RCLK0
+  RCLK1 RET ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7
+  VDDCE VDDC_L VDDC_R VDDP VDDPE VNWC VNWP VPW VSS VSSE WL0 WL1
** sram464x144WDX2: 20 flat devices **
X_M_dbl_load.MXNpg_0 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.425U L=0.04U
X_M_dbl_load.MXNpg_1 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.425U L=0.04U
X_M_wdx2.I69.MX_npd _WDX2.ROWSEL RET VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wdx2.I69.MX_nr_header VDDP RET VDDPE VNWP P11LL_CKT W=0.855U L=0.04U
X_M_wdx2.I69._nr.MXNA1 _WDX2.ROWSEL G0 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wdx2.I69._nr.MXNA2 _WDX2.ROWSEL G1 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wdx2.I69._nr.MXPA1 _WDX2.ROWSEL G0 _WDX2.I69._NR.P1 VNWP P11LL_CKT
+  W=0.855U L=0.04U
X_M_wdx2.I69._nr.MXPA2 _WDX2.I69._NR.P1 G1 VDDP VNWP P11LL_CKT W=0.855U
+  L=0.04U
X_M_wdx2._rowdrv_0.MXN10 INI0 RCLK0 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_M_wdx2._rowdrv_0.MXN11 WL0 _WDX2._ROWDRV_0.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_M_wdx2._rowdrv_0.MXN8 _WDX2._ROWDRV_0.NWL _WDX2.ROWSEL INI0 VPW N11LL_CKT
+  W=1.02U L=0.04U
X_M_wdx2._rowdrv_0.MXP1 WL0 _WDX2._ROWDRV_0.NWL VDDC_L VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_M_wdx2._rowdrv_0.MXP12 _WDX2._ROWDRV_0.NWL RCLK0 VDDCE VNWC P11LL_CKT
+  W=0.77U L=0.04U
X_M_wdx2._rowdrv_0.MXP13 _WDX2._ROWDRV_0.NWL _WDX2.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_M_wdx2._rowdrv_1.MXN10 INI1 RCLK1 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_M_wdx2._rowdrv_1.MXN11 WL1 _WDX2._ROWDRV_1.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_M_wdx2._rowdrv_1.MXN8 _WDX2._ROWDRV_1.NWL _WDX2.ROWSEL INI1 VPW N11LL_CKT
+  W=1.02U L=0.04U
X_M_wdx2._rowdrv_1.MXP1 WL1 _WDX2._ROWDRV_1.NWL VDDC_R VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_M_wdx2._rowdrv_1.MXP12 _WDX2._ROWDRV_1.NWL RCLK1 VDDCE VNWC P11LL_CKT
+  W=0.77U L=0.04U
X_M_wdx2._rowdrv_1.MXP13 _WDX2._ROWDRV_1.NWL _WDX2.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
.ENDS sram464x144WDX2
****
.SUBCKT sram464x144WDTOP_WDX64 BPGEN BRET1N BRET2N DBL LOG0_DWL NI0 NI1 NI2
+  NI3 NI4 NI5 NI6 NI7 NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 RET ROWCLK0 ROWCLK1
+  ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VDDCE VDDC_LEFT VDDC_RIGHT
+  VDDC_WL VDDP VDDPE VNWC VNWP VPW VSS VSSE
** sram464x144WDTOP_WDX64: 17 flat devices **
X_MXP2 NET95 RET VDDCE VNWC P11LL_CKT W=5.68U L=0.04U
X_M_wl_tcap_0.MXN0 NI0 ROWCLK0 VSSE VPW N11LL_CKT W=0.68U L=0.04U
X_M_wl_tcap_0.MXP2 NI0 ROWCLK0 NET95 VNWC P11LL_CKT W=1.56U L=0.04U
X_M_wl_tcap_1.MXN0 NI1 ROWCLK1 VSSE VPW N11LL_CKT W=0.68U L=0.04U
X_M_wl_tcap_1.MXP2 NI1 ROWCLK1 NET95 VNWC P11LL_CKT W=1.56U L=0.04U
X_M_wl_tcap_2.MXN0 NI2 ROWCLK2 VSSE VPW N11LL_CKT W=0.68U L=0.04U
X_M_wl_tcap_2.MXP2 NI2 ROWCLK2 NET95 VNWC P11LL_CKT W=1.56U L=0.04U
X_M_wl_tcap_3.MXN0 NI3 ROWCLK3 VSSE VPW N11LL_CKT W=0.68U L=0.04U
X_M_wl_tcap_3.MXP2 NI3 ROWCLK3 NET95 VNWC P11LL_CKT W=1.56U L=0.04U
X_M_wl_tcap_4.MXN0 NI4 ROWCLK4 VSSE VPW N11LL_CKT W=0.68U L=0.04U
X_M_wl_tcap_4.MXP2 NI4 ROWCLK4 NET95 VNWC P11LL_CKT W=1.56U L=0.04U
X_M_wl_tcap_5.MXN0 NI5 ROWCLK5 VSSE VPW N11LL_CKT W=0.68U L=0.04U
X_M_wl_tcap_5.MXP2 NI5 ROWCLK5 NET95 VNWC P11LL_CKT W=1.56U L=0.04U
X_M_wl_tcap_6.MXN0 NI6 ROWCLK6 VSSE VPW N11LL_CKT W=0.68U L=0.04U
X_M_wl_tcap_6.MXP2 NI6 ROWCLK6 NET95 VNWC P11LL_CKT W=1.56U L=0.04U
X_M_wl_tcap_7.MXN0 NI7 ROWCLK7 VSSE VPW N11LL_CKT W=0.68U L=0.04U
X_M_wl_tcap_7.MXP2 NI7 ROWCLK7 NET95 VNWC P11LL_CKT W=1.56U L=0.04U
.ENDS sram464x144WDTOP_WDX64
****
.SUBCKT sram464x144WDX64 ACTP A[0] A[1] A[2] A[3] A[4] A[5] DBL DFTRAM_RET DWL
+  EMA0 EMA1 EMA2 GTPCLK0 GTPCLK1 LA_P2[0] LA_P2[1] LA_P2[2] LOG0 LOG0_DWL
+  LOG1 NACTC NACT_CC NGWE NI0 NI1 NI2 NI3 NI4 NI5 NI6 NI7 NRETNVT NXP0_0
+  NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7 NXP1_0 NXP1_1 NXP1_2
+  NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 RET ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3
+  ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 SAE_DUMMY VDDCE VDDC_L VDDC_R VDDP VDDPE
+  VNWC VNWP VPW VSS VSSE WL0 WL1 WL2 WL3 WL4 WL5 WL6 WL7 WL8 WL9 WL10 WL11
+  WL12 WL13 WL14 WL15 WL16 WL17 WL18 WL19 WL20 WL21 WL22 WL23 WL24 WL25 WL26
+  WL27 WL28 WL29 WL30 WL31 WL32 WL33 WL34 WL35 WL36 WL37 WL38 WL39 WL40 WL41
+  WL42 WL43 WL44 WL45 WL46 WL47 WL48 WL49 WL50 WL51 WL52 WL53 WL54 WL55 WL56
+  WL57 WL58 WL59 WL60 WL61 WL62 WL63
** sram464x144WDX64: 1066 flat devices **
X_MI46_0.MXNA1 IA[0] NA[0] VSS VPW N11LL_CKT W=0.425U L=0.04U
X_MI46_0.MXPA1 IA[0] NA[0] VDDPE VNWP P11LL_CKT W=0.855U L=0.04U
X_MI46_1.MXNA1 IA[1] NA[1] VSS VPW N11LL_CKT W=0.425U L=0.04U
X_MI46_1.MXPA1 IA[1] NA[1] VDDPE VNWP P11LL_CKT W=0.855U L=0.04U
X_MI46_2.MXNA1 IA[2] NA[2] VSS VPW N11LL_CKT W=0.425U L=0.04U
X_MI46_2.MXPA1 IA[2] NA[2] VDDPE VNWP P11LL_CKT W=0.855U L=0.04U
X_MI47_0.MXNA1 NA[0] A[0] VSS VPW N11LL_CKT W=0.425U L=0.04U
X_MI47_0.MXPA1 NA[0] A[0] VDDPE VNWP P11LL_CKT W=0.855U L=0.04U
X_MI47_1.MXNA1 NA[1] A[1] VSS VPW N11LL_CKT W=0.425U L=0.04U
X_MI47_1.MXPA1 NA[1] A[1] VDDPE VNWP P11LL_CKT W=0.855U L=0.04U
X_MI47_2.MXNA1 NA[2] A[2] VSS VPW N11LL_CKT W=0.425U L=0.04U
X_MI47_2.MXPA1 NA[2] A[2] VDDPE VNWP P11LL_CKT W=0.855U L=0.04U
X_MI48.MXN0 IZERO I48.NODEB VSSE VPW N11LL_CKT W=0.51U L=0.04U
X_MI48.MXN1 I48.NODEA I48.NODEA VSSE VPW N11LL_CKT W=0.3U L=0.04U
X_MI48.MXN2 I48.NODEA I48.NODEB VSSE VPW N11LL_CKT W=0.3U L=0.04U
X_MI48.MXP1 I48.NODEB I48.NODEA VDDPE VNWP P11LL_CKT W=0.39U L=0.04U
X_MI48.MXP4 IONE I48.NODEA VDDPE VNWP P11LL_CKT W=1.04U L=0.04U
X_MI53.MXNA1 NACT_CC ACT_CC VSSE VPW N11LL_CKT W=1.42U L=0.04U
X_MI53.MXPA1 NACT_CC ACT_CC VDDPE VNWP P11LL_CKT W=2.84U L=0.04U
X_MI54.MXNA1 ACT_CC RET VSSE VPW N11LL_CKT W=0.425U L=0.04U
X_MI54.MXPA1 ACT_CC RET VDDPE VNWP P11LL_CKT W=0.85U L=0.04U
X_MI56.I69.MX_npd I56.ROWSEL DFTRAM_RET VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_MI56.I69.MX_nr_header VDDP DFTRAM_RET VDDPE VNWP P11LL_CKT W=0.855U L=0.04U
X_MI56.I69._nr.MXNA1 I56.ROWSEL NXP0_5 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_MI56.I69._nr.MXNA2 I56.ROWSEL NXP1_0 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_MI56.I69._nr.MXPA1 I56.ROWSEL NXP0_5 I56.I69._NR.P1 VNWP P11LL_CKT W=0.855U
+  L=0.04U
X_MI56.I69._nr.MXPA2 I56.I69._NR.P1 NXP1_0 VDDP VNWP P11LL_CKT W=0.855U
+  L=0.04U
X_MI56._rowdrv_0.MXN10 NI0 ROWCLK0 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_MI56._rowdrv_0.MXN11 WL40 I56._ROWDRV_0.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_MI56._rowdrv_0.MXN8 I56._ROWDRV_0.NWL I56.ROWSEL NI0 VPW N11LL_CKT W=1.02U
+  L=0.04U
X_MI56._rowdrv_0.MXP1 WL40 I56._ROWDRV_0.NWL VDDC_L VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_MI56._rowdrv_0.MXP12 I56._ROWDRV_0.NWL ROWCLK0 VDDCE VNWC P11LL_CKT W=0.77U
+  L=0.04U
X_MI56._rowdrv_0.MXP13 I56._ROWDRV_0.NWL I56.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_MI56._rowdrv_1.MXN10 NI1 ROWCLK1 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_MI56._rowdrv_1.MXN11 WL41 I56._ROWDRV_1.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_MI56._rowdrv_1.MXN8 I56._ROWDRV_1.NWL I56.ROWSEL NI1 VPW N11LL_CKT W=1.02U
+  L=0.04U
X_MI56._rowdrv_1.MXP1 WL41 I56._ROWDRV_1.NWL VDDC_R VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_MI56._rowdrv_1.MXP12 I56._ROWDRV_1.NWL ROWCLK1 VDDCE VNWC P11LL_CKT W=0.77U
+  L=0.04U
X_MI56._rowdrv_1.MXP13 I56._ROWDRV_1.NWL I56.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_MI57.I69.MX_npd I57.ROWSEL DFTRAM_RET VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_MI57.I69.MX_nr_header VDDP DFTRAM_RET VDDPE VNWP P11LL_CKT W=0.855U L=0.04U
X_MI57.I69._nr.MXNA1 I57.ROWSEL NXP0_5 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_MI57.I69._nr.MXNA2 I57.ROWSEL NXP1_0 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_MI57.I69._nr.MXPA1 I57.ROWSEL NXP0_5 I57.I69._NR.P1 VNWP P11LL_CKT W=0.855U
+  L=0.04U
X_MI57.I69._nr.MXPA2 I57.I69._NR.P1 NXP1_0 VDDP VNWP P11LL_CKT W=0.855U
+  L=0.04U
X_MI57._rowdrv_0.MXN10 NI2 ROWCLK2 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_MI57._rowdrv_0.MXN11 WL42 I57._ROWDRV_0.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_MI57._rowdrv_0.MXN8 I57._ROWDRV_0.NWL I57.ROWSEL NI2 VPW N11LL_CKT W=1.02U
+  L=0.04U
X_MI57._rowdrv_0.MXP1 WL42 I57._ROWDRV_0.NWL VDDC_L VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_MI57._rowdrv_0.MXP12 I57._ROWDRV_0.NWL ROWCLK2 VDDCE VNWC P11LL_CKT W=0.77U
+  L=0.04U
X_MI57._rowdrv_0.MXP13 I57._ROWDRV_0.NWL I57.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_MI57._rowdrv_1.MXN10 NI3 ROWCLK3 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_MI57._rowdrv_1.MXN11 WL43 I57._ROWDRV_1.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_MI57._rowdrv_1.MXN8 I57._ROWDRV_1.NWL I57.ROWSEL NI3 VPW N11LL_CKT W=1.02U
+  L=0.04U
X_MI57._rowdrv_1.MXP1 WL43 I57._ROWDRV_1.NWL VDDC_R VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_MI57._rowdrv_1.MXP12 I57._ROWDRV_1.NWL ROWCLK3 VDDCE VNWC P11LL_CKT W=0.77U
+  L=0.04U
X_MI57._rowdrv_1.MXP13 I57._ROWDRV_1.NWL I57.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_MI60.I69.MX_npd I60.ROWSEL DFTRAM_RET VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_MI60.I69.MX_nr_header VDDP DFTRAM_RET VDDPE VNWP P11LL_CKT W=0.855U L=0.04U
X_MI60.I69._nr.MXNA1 I60.ROWSEL NXP0_4 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_MI60.I69._nr.MXNA2 I60.ROWSEL NXP1_0 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_MI60.I69._nr.MXPA1 I60.ROWSEL NXP0_4 I60.I69._NR.P1 VNWP P11LL_CKT W=0.855U
+  L=0.04U
X_MI60.I69._nr.MXPA2 I60.I69._NR.P1 NXP1_0 VDDP VNWP P11LL_CKT W=0.855U
+  L=0.04U
X_MI60._rowdrv_0.MXN10 NI4 ROWCLK4 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_MI60._rowdrv_0.MXN11 WL36 I60._ROWDRV_0.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_MI60._rowdrv_0.MXN8 I60._ROWDRV_0.NWL I60.ROWSEL NI4 VPW N11LL_CKT W=1.02U
+  L=0.04U
X_MI60._rowdrv_0.MXP1 WL36 I60._ROWDRV_0.NWL VDDC_L VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_MI60._rowdrv_0.MXP12 I60._ROWDRV_0.NWL ROWCLK4 VDDCE VNWC P11LL_CKT W=0.77U
+  L=0.04U
X_MI60._rowdrv_0.MXP13 I60._ROWDRV_0.NWL I60.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_MI60._rowdrv_1.MXN10 NI5 ROWCLK5 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_MI60._rowdrv_1.MXN11 WL37 I60._ROWDRV_1.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_MI60._rowdrv_1.MXN8 I60._ROWDRV_1.NWL I60.ROWSEL NI5 VPW N11LL_CKT W=1.02U
+  L=0.04U
X_MI60._rowdrv_1.MXP1 WL37 I60._ROWDRV_1.NWL VDDC_R VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_MI60._rowdrv_1.MXP12 I60._ROWDRV_1.NWL ROWCLK5 VDDCE VNWC P11LL_CKT W=0.77U
+  L=0.04U
X_MI60._rowdrv_1.MXP13 I60._ROWDRV_1.NWL I60.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_MI61.I69.MX_npd I61.ROWSEL DFTRAM_RET VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_MI61.I69.MX_nr_header VDDP DFTRAM_RET VDDPE VNWP P11LL_CKT W=0.855U L=0.04U
X_MI61.I69._nr.MXNA1 I61.ROWSEL NXP0_4 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_MI61.I69._nr.MXNA2 I61.ROWSEL NXP1_0 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_MI61.I69._nr.MXPA1 I61.ROWSEL NXP0_4 I61.I69._NR.P1 VNWP P11LL_CKT W=0.855U
+  L=0.04U
X_MI61.I69._nr.MXPA2 I61.I69._NR.P1 NXP1_0 VDDP VNWP P11LL_CKT W=0.855U
+  L=0.04U
X_MI61._rowdrv_0.MXN10 NI6 ROWCLK6 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_MI61._rowdrv_0.MXN11 WL38 I61._ROWDRV_0.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_MI61._rowdrv_0.MXN8 I61._ROWDRV_0.NWL I61.ROWSEL NI6 VPW N11LL_CKT W=1.02U
+  L=0.04U
X_MI61._rowdrv_0.MXP1 WL38 I61._ROWDRV_0.NWL VDDC_L VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_MI61._rowdrv_0.MXP12 I61._ROWDRV_0.NWL ROWCLK6 VDDCE VNWC P11LL_CKT W=0.77U
+  L=0.04U
X_MI61._rowdrv_0.MXP13 I61._ROWDRV_0.NWL I61.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_MI61._rowdrv_1.MXN10 NI7 ROWCLK7 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_MI61._rowdrv_1.MXN11 WL39 I61._ROWDRV_1.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_MI61._rowdrv_1.MXN8 I61._ROWDRV_1.NWL I61.ROWSEL NI7 VPW N11LL_CKT W=1.02U
+  L=0.04U
X_MI61._rowdrv_1.MXP1 WL39 I61._ROWDRV_1.NWL VDDC_R VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_MI61._rowdrv_1.MXP12 I61._ROWDRV_1.NWL ROWCLK7 VDDCE VNWC P11LL_CKT W=0.77U
+  L=0.04U
X_MI61._rowdrv_1.MXP13 I61._ROWDRV_1.NWL I61.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_MI62.I69.MX_npd I62.ROWSEL DFTRAM_RET VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_MI62.I69.MX_nr_header VDDP DFTRAM_RET VDDPE VNWP P11LL_CKT W=0.855U L=0.04U
X_MI62.I69._nr.MXNA1 I62.ROWSEL NXP0_4 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_MI62.I69._nr.MXNA2 I62.ROWSEL NXP1_0 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_MI62.I69._nr.MXPA1 I62.ROWSEL NXP0_4 I62.I69._NR.P1 VNWP P11LL_CKT W=0.855U
+  L=0.04U
X_MI62.I69._nr.MXPA2 I62.I69._NR.P1 NXP1_0 VDDP VNWP P11LL_CKT W=0.855U
+  L=0.04U
X_MI62._rowdrv_0.MXN10 NI2 ROWCLK2 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_MI62._rowdrv_0.MXN11 WL34 I62._ROWDRV_0.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_MI62._rowdrv_0.MXN8 I62._ROWDRV_0.NWL I62.ROWSEL NI2 VPW N11LL_CKT W=1.02U
+  L=0.04U
X_MI62._rowdrv_0.MXP1 WL34 I62._ROWDRV_0.NWL VDDC_L VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_MI62._rowdrv_0.MXP12 I62._ROWDRV_0.NWL ROWCLK2 VDDCE VNWC P11LL_CKT W=0.77U
+  L=0.04U
X_MI62._rowdrv_0.MXP13 I62._ROWDRV_0.NWL I62.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_MI62._rowdrv_1.MXN10 NI3 ROWCLK3 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_MI62._rowdrv_1.MXN11 WL35 I62._ROWDRV_1.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_MI62._rowdrv_1.MXN8 I62._ROWDRV_1.NWL I62.ROWSEL NI3 VPW N11LL_CKT W=1.02U
+  L=0.04U
X_MI62._rowdrv_1.MXP1 WL35 I62._ROWDRV_1.NWL VDDC_R VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_MI62._rowdrv_1.MXP12 I62._ROWDRV_1.NWL ROWCLK3 VDDCE VNWC P11LL_CKT W=0.77U
+  L=0.04U
X_MI62._rowdrv_1.MXP13 I62._ROWDRV_1.NWL I62.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_MI63.I69.MX_npd I63.ROWSEL DFTRAM_RET VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_MI63.I69.MX_nr_header VDDP DFTRAM_RET VDDPE VNWP P11LL_CKT W=0.855U L=0.04U
X_MI63.I69._nr.MXNA1 I63.ROWSEL NXP0_4 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_MI63.I69._nr.MXNA2 I63.ROWSEL NXP1_0 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_MI63.I69._nr.MXPA1 I63.ROWSEL NXP0_4 I63.I69._NR.P1 VNWP P11LL_CKT W=0.855U
+  L=0.04U
X_MI63.I69._nr.MXPA2 I63.I69._NR.P1 NXP1_0 VDDP VNWP P11LL_CKT W=0.855U
+  L=0.04U
X_MI63._rowdrv_0.MXN10 NI0 ROWCLK0 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_MI63._rowdrv_0.MXN11 WL32 I63._ROWDRV_0.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_MI63._rowdrv_0.MXN8 I63._ROWDRV_0.NWL I63.ROWSEL NI0 VPW N11LL_CKT W=1.02U
+  L=0.04U
X_MI63._rowdrv_0.MXP1 WL32 I63._ROWDRV_0.NWL VDDC_L VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_MI63._rowdrv_0.MXP12 I63._ROWDRV_0.NWL ROWCLK0 VDDCE VNWC P11LL_CKT W=0.77U
+  L=0.04U
X_MI63._rowdrv_0.MXP13 I63._ROWDRV_0.NWL I63.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_MI63._rowdrv_1.MXN10 NI1 ROWCLK1 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_MI63._rowdrv_1.MXN11 WL33 I63._ROWDRV_1.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_MI63._rowdrv_1.MXN8 I63._ROWDRV_1.NWL I63.ROWSEL NI1 VPW N11LL_CKT W=1.02U
+  L=0.04U
X_MI63._rowdrv_1.MXP1 WL33 I63._ROWDRV_1.NWL VDDC_R VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_MI63._rowdrv_1.MXP12 I63._ROWDRV_1.NWL ROWCLK1 VDDCE VNWC P11LL_CKT W=0.77U
+  L=0.04U
X_MI63._rowdrv_1.MXP13 I63._ROWDRV_1.NWL I63.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_MI78.I1_0.MXNA1 I78.NDEC[0] NLA_P2[0] I78.I1_0.N2 VPW N11LL_CKT W=0.425U
+  L=0.04U
X_MI78.I1_0.MXNA2 I78.I1_0.N2 NLA_P2[1] I78.I1_0.N1 VPW N11LL_CKT W=0.425U
+  L=0.04U
X_MI78.I1_0.MXNA3 I78.I1_0.N1 NLA_P2[2] VSS VPW N11LL_CKT W=0.425U L=0.04U
X_MI78.I1_0.MXPA1 I78.NDEC[0] NLA_P2[0] VDDPE VNWP P11LL_CKT W=0.425U L=0.04U
X_MI78.I1_0.MXPA2 I78.NDEC[0] NLA_P2[1] VDDPE VNWP P11LL_CKT W=0.425U L=0.04U
X_MI78.I1_0.MXPA3 I78.NDEC[0] NLA_P2[2] VDDPE VNWP P11LL_CKT W=0.425U L=0.04U
X_MI78.I1_1.MXNA1 I78.NDEC[1] LA_P2[0] I78.I1_1.N2 VPW N11LL_CKT W=0.425U
+  L=0.04U
X_MI78.I1_1.MXNA2 I78.I1_1.N2 NLA_P2[1] I78.I1_1.N1 VPW N11LL_CKT W=0.425U
+  L=0.04U
X_MI78.I1_1.MXNA3 I78.I1_1.N1 NLA_P2[2] VSS VPW N11LL_CKT W=0.425U L=0.04U
X_MI78.I1_1.MXPA1 I78.NDEC[1] LA_P2[0] VDDPE VNWP P11LL_CKT W=0.425U L=0.04U
X_MI78.I1_1.MXPA2 I78.NDEC[1] NLA_P2[1] VDDPE VNWP P11LL_CKT W=0.425U L=0.04U
X_MI78.I1_1.MXPA3 I78.NDEC[1] NLA_P2[2] VDDPE VNWP P11LL_CKT W=0.425U L=0.04U
X_MI78.I1_2.MXNA1 I78.NDEC[2] NLA_P2[0] I78.I1_2.N2 VPW N11LL_CKT W=0.425U
+  L=0.04U
X_MI78.I1_2.MXNA2 I78.I1_2.N2 LA_P2[1] I78.I1_2.N1 VPW N11LL_CKT W=0.425U
+  L=0.04U
X_MI78.I1_2.MXNA3 I78.I1_2.N1 NLA_P2[2] VSS VPW N11LL_CKT W=0.425U L=0.04U
X_MI78.I1_2.MXPA1 I78.NDEC[2] NLA_P2[0] VDDPE VNWP P11LL_CKT W=0.425U L=0.04U
X_MI78.I1_2.MXPA2 I78.NDEC[2] LA_P2[1] VDDPE VNWP P11LL_CKT W=0.425U L=0.04U
X_MI78.I1_2.MXPA3 I78.NDEC[2] NLA_P2[2] VDDPE VNWP P11LL_CKT W=0.425U L=0.04U
X_MI78.I1_3.MXNA1 I78.NDEC[3] LA_P2[0] I78.I1_3.N2 VPW N11LL_CKT W=0.425U
+  L=0.04U
X_MI78.I1_3.MXNA2 I78.I1_3.N2 LA_P2[1] I78.I1_3.N1 VPW N11LL_CKT W=0.425U
+  L=0.04U
X_MI78.I1_3.MXNA3 I78.I1_3.N1 NLA_P2[2] VSS VPW N11LL_CKT W=0.425U L=0.04U
X_MI78.I1_3.MXPA1 I78.NDEC[3] LA_P2[0] VDDPE VNWP P11LL_CKT W=0.425U L=0.04U
X_MI78.I1_3.MXPA2 I78.NDEC[3] LA_P2[1] VDDPE VNWP P11LL_CKT W=0.425U L=0.04U
X_MI78.I1_3.MXPA3 I78.NDEC[3] NLA_P2[2] VDDPE VNWP P11LL_CKT W=0.425U L=0.04U
X_MI78.I1_4.MXNA1 I78.NDEC[4] NLA_P2[0] I78.I1_4.N2 VPW N11LL_CKT W=0.425U
+  L=0.04U
X_MI78.I1_4.MXNA2 I78.I1_4.N2 NLA_P2[1] I78.I1_4.N1 VPW N11LL_CKT W=0.425U
+  L=0.04U
X_MI78.I1_4.MXNA3 I78.I1_4.N1 LA_P2[2] VSS VPW N11LL_CKT W=0.425U L=0.04U
X_MI78.I1_4.MXPA1 I78.NDEC[4] NLA_P2[0] VDDPE VNWP P11LL_CKT W=0.425U L=0.04U
X_MI78.I1_4.MXPA2 I78.NDEC[4] NLA_P2[1] VDDPE VNWP P11LL_CKT W=0.425U L=0.04U
X_MI78.I1_4.MXPA3 I78.NDEC[4] LA_P2[2] VDDPE VNWP P11LL_CKT W=0.425U L=0.04U
X_MI78.I1_5.MXNA1 I78.NDEC[5] LA_P2[0] I78.I1_5.N2 VPW N11LL_CKT W=0.425U
+  L=0.04U
X_MI78.I1_5.MXNA2 I78.I1_5.N2 NLA_P2[1] I78.I1_5.N1 VPW N11LL_CKT W=0.425U
+  L=0.04U
X_MI78.I1_5.MXNA3 I78.I1_5.N1 LA_P2[2] VSS VPW N11LL_CKT W=0.425U L=0.04U
X_MI78.I1_5.MXPA1 I78.NDEC[5] LA_P2[0] VDDPE VNWP P11LL_CKT W=0.425U L=0.04U
X_MI78.I1_5.MXPA2 I78.NDEC[5] NLA_P2[1] VDDPE VNWP P11LL_CKT W=0.425U L=0.04U
X_MI78.I1_5.MXPA3 I78.NDEC[5] LA_P2[2] VDDPE VNWP P11LL_CKT W=0.425U L=0.04U
X_MI78.I1_6.MXNA1 I78.NDEC[6] NLA_P2[0] I78.I1_6.N2 VPW N11LL_CKT W=0.425U
+  L=0.04U
X_MI78.I1_6.MXNA2 I78.I1_6.N2 LA_P2[1] I78.I1_6.N1 VPW N11LL_CKT W=0.425U
+  L=0.04U
X_MI78.I1_6.MXNA3 I78.I1_6.N1 LA_P2[2] VSS VPW N11LL_CKT W=0.425U L=0.04U
X_MI78.I1_6.MXPA1 I78.NDEC[6] NLA_P2[0] VDDPE VNWP P11LL_CKT W=0.425U L=0.04U
X_MI78.I1_6.MXPA2 I78.NDEC[6] LA_P2[1] VDDPE VNWP P11LL_CKT W=0.425U L=0.04U
X_MI78.I1_6.MXPA3 I78.NDEC[6] LA_P2[2] VDDPE VNWP P11LL_CKT W=0.425U L=0.04U
X_MI78.I1_7.MXNA1 I78.NDEC[7] LA_P2[0] I78.I1_7.N2 VPW N11LL_CKT W=0.425U
+  L=0.04U
X_MI78.I1_7.MXNA2 I78.I1_7.N2 LA_P2[1] I78.I1_7.N1 VPW N11LL_CKT W=0.425U
+  L=0.04U
X_MI78.I1_7.MXNA3 I78.I1_7.N1 LA_P2[2] VSS VPW N11LL_CKT W=0.425U L=0.04U
X_MI78.I1_7.MXPA1 I78.NDEC[7] LA_P2[0] VDDPE VNWP P11LL_CKT W=0.425U L=0.04U
X_MI78.I1_7.MXPA2 I78.NDEC[7] LA_P2[1] VDDPE VNWP P11LL_CKT W=0.425U L=0.04U
X_MI78.I1_7.MXPA3 I78.NDEC[7] LA_P2[2] VDDPE VNWP P11LL_CKT W=0.425U L=0.04U
X_MI78.I3_0.MXNA1 XROW[0] I78.NDEC[0] VSS VPW N11LL_CKT W=0.43U L=0.04U
X_MI78.I3_0.MXPA1 XROW[0] I78.NDEC[0] VDDPE VNWP P11LL_CKT W=0.85U L=0.04U
X_MI78.I3_1.MXNA1 XROW[1] I78.NDEC[1] VSS VPW N11LL_CKT W=0.43U L=0.04U
X_MI78.I3_1.MXPA1 XROW[1] I78.NDEC[1] VDDPE VNWP P11LL_CKT W=0.85U L=0.04U
X_MI78.I3_2.MXNA1 XROW[2] I78.NDEC[2] VSS VPW N11LL_CKT W=0.43U L=0.04U
X_MI78.I3_2.MXPA1 XROW[2] I78.NDEC[2] VDDPE VNWP P11LL_CKT W=0.85U L=0.04U
X_MI78.I3_3.MXNA1 XROW[3] I78.NDEC[3] VSS VPW N11LL_CKT W=0.43U L=0.04U
X_MI78.I3_3.MXPA1 XROW[3] I78.NDEC[3] VDDPE VNWP P11LL_CKT W=0.85U L=0.04U
X_MI78.I3_4.MXNA1 XROW[4] I78.NDEC[4] VSS VPW N11LL_CKT W=0.43U L=0.04U
X_MI78.I3_4.MXPA1 XROW[4] I78.NDEC[4] VDDPE VNWP P11LL_CKT W=0.85U L=0.04U
X_MI78.I3_5.MXNA1 XROW[5] I78.NDEC[5] VSS VPW N11LL_CKT W=0.43U L=0.04U
X_MI78.I3_5.MXPA1 XROW[5] I78.NDEC[5] VDDPE VNWP P11LL_CKT W=0.85U L=0.04U
X_MI78.I3_6.MXNA1 XROW[6] I78.NDEC[6] VSS VPW N11LL_CKT W=0.43U L=0.04U
X_MI78.I3_6.MXPA1 XROW[6] I78.NDEC[6] VDDPE VNWP P11LL_CKT W=0.85U L=0.04U
X_MI78.I3_7.MXNA1 XROW[7] I78.NDEC[7] VSS VPW N11LL_CKT W=0.43U L=0.04U
X_MI78.I3_7.MXPA1 XROW[7] I78.NDEC[7] VDDPE VNWP P11LL_CKT W=0.85U L=0.04U
X_MI79.MXNA1 NLA_P2[1] LA_P2[1] VSS VPW N11LL_CKT W=0.215U L=0.04U
X_MI79.MXPA1 NLA_P2[1] LA_P2[1] VDDPE VNWP P11LL_CKT W=0.425U L=0.04U
X_MI80.MXNA1 NLA_P2[0] LA_P2[0] VSS VPW N11LL_CKT W=0.215U L=0.04U
X_MI80.MXPA1 NLA_P2[0] LA_P2[0] VDDPE VNWP P11LL_CKT W=0.425U L=0.04U
X_MI81.MXNA1 NLA_P2[2] LA_P2[2] VSS VPW N11LL_CKT W=0.215U L=0.04U
X_MI81.MXPA1 NLA_P2[2] LA_P2[2] VDDPE VNWP P11LL_CKT W=0.425U L=0.04U
X_MInv_add_2_3.MXNA1 IA[3] NA[3] VSS VPW N11LL_CKT W=0.425U L=0.04U
X_MInv_add_2_3.MXPA1 IA[3] NA[3] VDDPE VNWP P11LL_CKT W=0.855U L=0.04U
X_MInv_add_2_4.MXNA1 IA[4] NA[4] VSS VPW N11LL_CKT W=0.425U L=0.04U
X_MInv_add_2_4.MXPA1 IA[4] NA[4] VDDPE VNWP P11LL_CKT W=0.855U L=0.04U
X_MInv_add_2_5.MXNA1 IA[5] NA[5] VSS VPW N11LL_CKT W=0.425U L=0.04U
X_MInv_add_2_5.MXPA1 IA[5] NA[5] VDDPE VNWP P11LL_CKT W=0.855U L=0.04U
X_MInv_add_3.MXNA1 NA[3] A[3] VSS VPW N11LL_CKT W=0.425U L=0.04U
X_MInv_add_3.MXPA1 NA[3] A[3] VDDPE VNWP P11LL_CKT W=0.855U L=0.04U
X_MInv_add_4.MXNA1 NA[4] A[4] VSS VPW N11LL_CKT W=0.425U L=0.04U
X_MInv_add_4.MXPA1 NA[4] A[4] VDDPE VNWP P11LL_CKT W=0.855U L=0.04U
X_MInv_add_5.MXNA1 NA[5] A[5] VSS VPW N11LL_CKT W=0.425U L=0.04U
X_MInv_add_5.MXPA1 NA[5] A[5] VDDPE VNWP P11LL_CKT W=0.855U L=0.04U
X_MXN1 VSS DBL VSS VPW N11LL_CKT W=2.85U L=0.04U
X_MXN5 LOG0 IONE VSSE VPW N11LL_CKT W=3.98U L=0.04U
X_MXN7 LOG0_DWL IONE VSSE VPW N11LL_CKT W=2.84U L=0.04U
X_MXP3 VDDPE DBL VDDPE VNWP P11LL_CKT W=3.55U L=0.04U
X_MXP4 LOG1 IZERO VDDPE VNWP P11LL_CKT W=5.13U L=0.04U
X_M_cmuxsa_dummy.I68.MXNA1 SAE_DUMMY DBL VSSE VPW N11LL_CKT W=1.13U L=0.04U
X_M_cmuxsa_dummy.I68.MXPA1 SAE_DUMMY DBL VDDPE VNWP P11LL_CKT W=2.265U L=0.04U
X_M_cmuxsa_dummy.MXN0 VSS DBL VSS VPW N11LL_CKT W=1.875U L=0.085U
X_M_cmuxsa_dummy.MXN1 VSS DBL VSS VPW N11LL_CKT W=0.285U L=0.04U
X_M_cmuxsa_dummy.MXN4_0 DBL LOG0 DBL VPW N11LL_CKT W=0.47U L=0.04U
X_M_cmuxsa_dummy.MXN4_1 DBL LOG0 DBL VPW N11LL_CKT W=0.47U L=0.04U
X_M_cmuxsa_dummy.MXP1_0 DBL LOG0 DBL VNWP P11LL_CKT W=0.485U L=0.04U
X_M_cmuxsa_dummy.MXP1_1 DBL LOG0 DBL VNWP P11LL_CKT W=0.485U L=0.04U
X_M_cmuxsa_dummy.MXP2 VDDPE DBL VDDPE VNWP P11LL_CKT W=0.48U L=0.04U
X_M_cmuxsa_dummy.MXP3 VDDPE DBL VDDPE VNWP P11LL_CKT W=0.57U L=0.04U
X_M_cmuxsa_dummy.MXPPU1_0 DBL LOG0 DBL VNWP P11LL_CKT W=0.4U L=0.04U
X_M_cmuxsa_dummy.MXPPU1_1 DBL LOG0 DBL VNWP P11LL_CKT W=0.4U L=0.04U
X_M_dbl_load_0.MXNpg_0 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_0.MXNpg_1 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_1.MXNpg_0 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_1.MXNpg_1 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_10.MXNpg_0 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_10.MXNpg_1 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_11.MXNpg_0 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_11.MXNpg_1 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_12.MXNpg_0 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_12.MXNpg_1 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_13.MXNpg_0 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_13.MXNpg_1 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_14.MXNpg_0 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_14.MXNpg_1 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_15.MXNpg_0 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_15.MXNpg_1 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_16.MXNpg_0 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_16.MXNpg_1 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_17.MXNpg_0 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_17.MXNpg_1 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_18.MXNpg_0 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_18.MXNpg_1 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_19.MXNpg_0 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_19.MXNpg_1 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_2.MXNpg_0 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_2.MXNpg_1 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_20.MXNpg_0 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_20.MXNpg_1 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_21.MXNpg_0 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_21.MXNpg_1 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_22.MXNpg_0 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_22.MXNpg_1 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_23.MXNpg_0 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_23.MXNpg_1 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_24.MXNpg_0 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_24.MXNpg_1 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_25.MXNpg_0 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_25.MXNpg_1 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_26.MXNpg_0 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_26.MXNpg_1 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_27.MXNpg_0 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_27.MXNpg_1 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_28.MXNpg_0 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_28.MXNpg_1 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_29.MXNpg_0 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_29.MXNpg_1 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_3.MXNpg_0 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_3.MXNpg_1 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_30.MXNpg_0 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_30.MXNpg_1 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_31.MXNpg_0 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_31.MXNpg_1 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_32.MXNpg_0 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_32.MXNpg_1 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_33.MXNpg_0 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_33.MXNpg_1 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_34.MXNpg_0 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_34.MXNpg_1 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_35.MXNpg_0 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_35.MXNpg_1 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_36.MXNpg_0 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_36.MXNpg_1 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_37.MXNpg_0 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_37.MXNpg_1 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_38.MXNpg_0 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_38.MXNpg_1 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_39.MXNpg_0 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_39.MXNpg_1 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_4.MXNpg_0 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_4.MXNpg_1 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_40.MXNpg_0 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_40.MXNpg_1 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_41.MXNpg_0 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_41.MXNpg_1 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_42.MXNpg_0 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_42.MXNpg_1 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_43.MXNpg_0 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_43.MXNpg_1 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_44.MXNpg_0 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_44.MXNpg_1 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_45.MXNpg_0 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_45.MXNpg_1 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_46.MXNpg_0 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_46.MXNpg_1 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_47.MXNpg_0 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_47.MXNpg_1 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_48.MXNpg_0 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_48.MXNpg_1 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_49.MXNpg_0 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_49.MXNpg_1 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_5.MXNpg_0 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_5.MXNpg_1 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_50.MXNpg_0 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_50.MXNpg_1 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_51.MXNpg_0 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_51.MXNpg_1 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_52.MXNpg_0 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_52.MXNpg_1 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_53.MXNpg_0 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_53.MXNpg_1 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_54.MXNpg_0 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_54.MXNpg_1 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_55.MXNpg_0 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_55.MXNpg_1 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_56.MXNpg_0 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_56.MXNpg_1 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_57.MXNpg_0 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_57.MXNpg_1 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_58.MXNpg_0 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_58.MXNpg_1 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_59.MXNpg_0 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_59.MXNpg_1 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_6.MXNpg_0 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_6.MXNpg_1 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_60.MXNpg_0 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_60.MXNpg_1 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_61.MXNpg_0 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_61.MXNpg_1 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_7.MXNpg_0 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_7.MXNpg_1 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_8.MXNpg_0 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_8.MXNpg_1 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_9.MXNpg_0 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dbl_load_9.MXNpg_1 DBL LOG0_DWL LOG0_DWL VPW N11LL_CKT W=0.12U L=0.04U
X_M_dummy.I81.MXNA1 _DUMMY.NSEL0 EMA2 VSSE VPW N11LL_CKT W=0.145U L=0.04U
X_M_dummy.I81.MXNA2 _DUMMY.NSEL0 EMA0 VSSE VPW N11LL_CKT W=0.145U L=0.04U
X_M_dummy.I81.MXPA1 _DUMMY.NSEL0 EMA2 _DUMMY.I81.P1 VNWP P11LL_CKT W=0.285U
+  L=0.04U
X_M_dummy.I81.MXPA2 _DUMMY.I81.P1 EMA0 VDDPE VNWP P11LL_CKT W=0.285U L=0.04U
X_M_dummy.I82.MXNA1 _DUMMY.NSEL1 EMA2 VSSE VPW N11LL_CKT W=0.145U L=0.04U
X_M_dummy.I82.MXNA2 _DUMMY.NSEL1 EMA1 VSSE VPW N11LL_CKT W=0.145U L=0.04U
X_M_dummy.I82.MXPA1 _DUMMY.NSEL1 EMA2 _DUMMY.I82.P1 VNWP P11LL_CKT W=0.285U
+  L=0.04U
X_M_dummy.I82.MXPA2 _DUMMY.I82.P1 EMA1 VDDPE VNWP P11LL_CKT W=0.285U L=0.04U
X_M_dummy.I83.MXNA1 _DUMMY.NIDBL DBL VSSE VPW N11LL_CKT W=0.145U L=0.04U
X_M_dummy.I83.MXPA1 _DUMMY.NIDBL DBL VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_M_dummy.MXN34 I[2] LOG1 VSSE VPW N11LL_CKT W=0.8U L=0.04U
X_M_dummy.MXN35 DBL DWL _DUMMY.IA[1] VPW N11LL_CKT W=0.5U L=0.04U
X_M_dummy.MXN36 DBL DWL _DUMMY.IA[0] VPW N11LL_CKT W=0.35U L=0.04U
X_M_dummy.MXN37 DBL DWL _DUMMY.IA[3] VPW N11LL_CKT W=0.3U L=0.04U
X_M_dummy.MXN38 VSSE LOG1 VSSE VPW N11LL_CKT W=0.3U L=0.04U
X_M_dummy.MXN39 _DUMMY.IA[2] _DUMMY.NSEL1 I[2] VPW N11LL_CKT W=0.8U L=0.04U
X_M_dummy.MXN40 _DUMMY.IA[1] _DUMMY.NSEL0 I[1] VPW N11LL_CKT W=0.5U L=0.04U
X_M_dummy.MXN41 _DUMMY.IA[3] LOG1 VSSE VPW N11LL_CKT W=0.3U L=0.04U
X_M_dummy.MXN42 DBL DWL _DUMMY.IA[4] VPW N11LL_CKT W=0.35U L=0.04U
X_M_dummy.MXN43 I[4] LOG1 VSSE VPW N11LL_CKT W=0.35U L=0.04U
X_M_dummy.MXN44 _DUMMY.IA[4] LOG1 I[4] VPW N11LL_CKT W=0.35U L=0.04U
X_M_dummy.MXN45 _DUMMY.IA[0] LOG1 VSSE VPW N11LL_CKT W=0.35U L=0.04U
X_M_dummy.MXN46 DBL DWL _DUMMY.IA[2] VPW N11LL_CKT W=0.8U L=0.04U
X_M_dummy.MXN47 VSSE LOG1 VSSE VPW N11LL_CKT W=0.35U L=0.04U
X_M_dummy.MXN48 I[1] LOG1 VSSE VPW N11LL_CKT W=0.5U L=0.04U
X_M_dummy.MXP13 DBL LOG1 _DUMMY.NET60 VNWP P11LL_CKT W=0.285U L=0.04U
X_M_dummy.MXP14 DBL DWL VDDPE VNWP P11LL_CKT W=3.55U L=0.04U
X_M_dummy.MXP15 _DUMMY.NET60 _DUMMY.NIDBL VDDPE VNWP P11LL_CKT W=0.285U
+  L=0.04U
X_M_dummy.MXP16 _DUMMY.NET68 _DUMMY.NIDBL VDDPE VNWP P11LL_CKT W=0.285U
+  L=0.04U
X_M_dummy.MXP17 DBL LOG1 _DUMMY.NET68 VNWP P11LL_CKT W=0.285U L=0.04U
X_M_rowdrv_0.I2.MXNA1 _ROWDRV_0.NROWCLK GTPCLK0 _ROWDRV_0.I2.N1 VPW N11LL_CKT
+  W=2.27U L=0.04U
X_M_rowdrv_0.I2.MXNA2 _ROWDRV_0.I2.N1 XROW[0] VSS VPW N11LL_CKT W=2.835U
+  L=0.04U
X_M_rowdrv_0.I2.MXPA1 _ROWDRV_0.NROWCLK GTPCLK0 VDDPE VNWP P11LL_CKT W=1.71U
+  L=0.04U
X_M_rowdrv_0.I2.MXPA2 _ROWDRV_0.NROWCLK XROW[0] VDDPE VNWP P11LL_CKT W=0.86U
+  L=0.04U
X_M_rowdrv_0.IV_RdWrClk.MXNA1 ROWCLK0 _ROWDRV_0.NROWCLK VSSE VPW N11LL_CKT
+  W=3.9U L=0.04U
X_M_rowdrv_0.IV_RdWrClk.MXPA1 ROWCLK0 _ROWDRV_0.NROWCLK VDDPE VNWP P11LL_CKT
+  W=8.1U L=0.04U
X_M_rowdrv_0.MXN0 NI0 ROWCLK0 VSSE VPW N11LL_CKT W=0.68U L=0.04U
X_M_rowdrv_1.I2.MXNA1 _ROWDRV_1.NROWCLK GTPCLK1 _ROWDRV_1.I2.N1 VPW N11LL_CKT
+  W=2.27U L=0.04U
X_M_rowdrv_1.I2.MXNA2 _ROWDRV_1.I2.N1 XROW[1] VSS VPW N11LL_CKT W=2.835U
+  L=0.04U
X_M_rowdrv_1.I2.MXPA1 _ROWDRV_1.NROWCLK GTPCLK1 VDDPE VNWP P11LL_CKT W=1.71U
+  L=0.04U
X_M_rowdrv_1.I2.MXPA2 _ROWDRV_1.NROWCLK XROW[1] VDDPE VNWP P11LL_CKT W=0.86U
+  L=0.04U
X_M_rowdrv_1.IV_RdWrClk.MXNA1 ROWCLK1 _ROWDRV_1.NROWCLK VSSE VPW N11LL_CKT
+  W=3.9U L=0.04U
X_M_rowdrv_1.IV_RdWrClk.MXPA1 ROWCLK1 _ROWDRV_1.NROWCLK VDDPE VNWP P11LL_CKT
+  W=8.1U L=0.04U
X_M_rowdrv_1.MXN0 NI1 ROWCLK1 VSSE VPW N11LL_CKT W=0.68U L=0.04U
X_M_rowdrv_2.I2.MXNA1 _ROWDRV_2.NROWCLK GTPCLK0 _ROWDRV_2.I2.N1 VPW N11LL_CKT
+  W=2.27U L=0.04U
X_M_rowdrv_2.I2.MXNA2 _ROWDRV_2.I2.N1 XROW[2] VSS VPW N11LL_CKT W=2.835U
+  L=0.04U
X_M_rowdrv_2.I2.MXPA1 _ROWDRV_2.NROWCLK GTPCLK0 VDDPE VNWP P11LL_CKT W=1.71U
+  L=0.04U
X_M_rowdrv_2.I2.MXPA2 _ROWDRV_2.NROWCLK XROW[2] VDDPE VNWP P11LL_CKT W=0.86U
+  L=0.04U
X_M_rowdrv_2.IV_RdWrClk.MXNA1 ROWCLK2 _ROWDRV_2.NROWCLK VSSE VPW N11LL_CKT
+  W=3.9U L=0.04U
X_M_rowdrv_2.IV_RdWrClk.MXPA1 ROWCLK2 _ROWDRV_2.NROWCLK VDDPE VNWP P11LL_CKT
+  W=8.1U L=0.04U
X_M_rowdrv_2.MXN0 NI2 ROWCLK2 VSSE VPW N11LL_CKT W=0.68U L=0.04U
X_M_rowdrv_3.I2.MXNA1 _ROWDRV_3.NROWCLK GTPCLK1 _ROWDRV_3.I2.N1 VPW N11LL_CKT
+  W=2.27U L=0.04U
X_M_rowdrv_3.I2.MXNA2 _ROWDRV_3.I2.N1 XROW[3] VSS VPW N11LL_CKT W=2.835U
+  L=0.04U
X_M_rowdrv_3.I2.MXPA1 _ROWDRV_3.NROWCLK GTPCLK1 VDDPE VNWP P11LL_CKT W=1.71U
+  L=0.04U
X_M_rowdrv_3.I2.MXPA2 _ROWDRV_3.NROWCLK XROW[3] VDDPE VNWP P11LL_CKT W=0.86U
+  L=0.04U
X_M_rowdrv_3.IV_RdWrClk.MXNA1 ROWCLK3 _ROWDRV_3.NROWCLK VSSE VPW N11LL_CKT
+  W=3.9U L=0.04U
X_M_rowdrv_3.IV_RdWrClk.MXPA1 ROWCLK3 _ROWDRV_3.NROWCLK VDDPE VNWP P11LL_CKT
+  W=8.1U L=0.04U
X_M_rowdrv_3.MXN0 NI3 ROWCLK3 VSSE VPW N11LL_CKT W=0.68U L=0.04U
X_M_rowdrv_4.I2.MXNA1 _ROWDRV_4.NROWCLK GTPCLK0 _ROWDRV_4.I2.N1 VPW N11LL_CKT
+  W=2.27U L=0.04U
X_M_rowdrv_4.I2.MXNA2 _ROWDRV_4.I2.N1 XROW[4] VSS VPW N11LL_CKT W=2.835U
+  L=0.04U
X_M_rowdrv_4.I2.MXPA1 _ROWDRV_4.NROWCLK GTPCLK0 VDDPE VNWP P11LL_CKT W=1.71U
+  L=0.04U
X_M_rowdrv_4.I2.MXPA2 _ROWDRV_4.NROWCLK XROW[4] VDDPE VNWP P11LL_CKT W=0.86U
+  L=0.04U
X_M_rowdrv_4.IV_RdWrClk.MXNA1 ROWCLK4 _ROWDRV_4.NROWCLK VSSE VPW N11LL_CKT
+  W=3.9U L=0.04U
X_M_rowdrv_4.IV_RdWrClk.MXPA1 ROWCLK4 _ROWDRV_4.NROWCLK VDDPE VNWP P11LL_CKT
+  W=8.1U L=0.04U
X_M_rowdrv_4.MXN0 NI4 ROWCLK4 VSSE VPW N11LL_CKT W=0.68U L=0.04U
X_M_rowdrv_5.I2.MXNA1 _ROWDRV_5.NROWCLK GTPCLK1 _ROWDRV_5.I2.N1 VPW N11LL_CKT
+  W=2.27U L=0.04U
X_M_rowdrv_5.I2.MXNA2 _ROWDRV_5.I2.N1 XROW[5] VSS VPW N11LL_CKT W=2.835U
+  L=0.04U
X_M_rowdrv_5.I2.MXPA1 _ROWDRV_5.NROWCLK GTPCLK1 VDDPE VNWP P11LL_CKT W=1.71U
+  L=0.04U
X_M_rowdrv_5.I2.MXPA2 _ROWDRV_5.NROWCLK XROW[5] VDDPE VNWP P11LL_CKT W=0.86U
+  L=0.04U
X_M_rowdrv_5.IV_RdWrClk.MXNA1 ROWCLK5 _ROWDRV_5.NROWCLK VSSE VPW N11LL_CKT
+  W=3.9U L=0.04U
X_M_rowdrv_5.IV_RdWrClk.MXPA1 ROWCLK5 _ROWDRV_5.NROWCLK VDDPE VNWP P11LL_CKT
+  W=8.1U L=0.04U
X_M_rowdrv_5.MXN0 NI5 ROWCLK5 VSSE VPW N11LL_CKT W=0.68U L=0.04U
X_M_rowdrv_6.I2.MXNA1 _ROWDRV_6.NROWCLK GTPCLK0 _ROWDRV_6.I2.N1 VPW N11LL_CKT
+  W=2.27U L=0.04U
X_M_rowdrv_6.I2.MXNA2 _ROWDRV_6.I2.N1 XROW[6] VSS VPW N11LL_CKT W=2.835U
+  L=0.04U
X_M_rowdrv_6.I2.MXPA1 _ROWDRV_6.NROWCLK GTPCLK0 VDDPE VNWP P11LL_CKT W=1.71U
+  L=0.04U
X_M_rowdrv_6.I2.MXPA2 _ROWDRV_6.NROWCLK XROW[6] VDDPE VNWP P11LL_CKT W=0.86U
+  L=0.04U
X_M_rowdrv_6.IV_RdWrClk.MXNA1 ROWCLK6 _ROWDRV_6.NROWCLK VSSE VPW N11LL_CKT
+  W=3.9U L=0.04U
X_M_rowdrv_6.IV_RdWrClk.MXPA1 ROWCLK6 _ROWDRV_6.NROWCLK VDDPE VNWP P11LL_CKT
+  W=8.1U L=0.04U
X_M_rowdrv_6.MXN0 NI6 ROWCLK6 VSSE VPW N11LL_CKT W=0.68U L=0.04U
X_M_rowdrv_7.I2.MXNA1 _ROWDRV_7.NROWCLK GTPCLK1 _ROWDRV_7.I2.N1 VPW N11LL_CKT
+  W=2.27U L=0.04U
X_M_rowdrv_7.I2.MXNA2 _ROWDRV_7.I2.N1 XROW[7] VSS VPW N11LL_CKT W=2.835U
+  L=0.04U
X_M_rowdrv_7.I2.MXPA1 _ROWDRV_7.NROWCLK GTPCLK1 VDDPE VNWP P11LL_CKT W=1.71U
+  L=0.04U
X_M_rowdrv_7.I2.MXPA2 _ROWDRV_7.NROWCLK XROW[7] VDDPE VNWP P11LL_CKT W=0.86U
+  L=0.04U
X_M_rowdrv_7.IV_RdWrClk.MXNA1 ROWCLK7 _ROWDRV_7.NROWCLK VSSE VPW N11LL_CKT
+  W=3.9U L=0.04U
X_M_rowdrv_7.IV_RdWrClk.MXPA1 ROWCLK7 _ROWDRV_7.NROWCLK VDDPE VNWP P11LL_CKT
+  W=8.1U L=0.04U
X_M_rowdrv_7.MXN0 NI7 ROWCLK7 VSSE VPW N11LL_CKT W=0.68U L=0.04U
X_M_wd0.I69.MX_npd _WD0.ROWSEL DFTRAM_RET VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd0.I69.MX_nr_header VDDP DFTRAM_RET VDDPE VNWP P11LL_CKT W=0.855U L=0.04U
X_M_wd0.I69._nr.MXNA1 _WD0.ROWSEL NXP0_0 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd0.I69._nr.MXNA2 _WD0.ROWSEL NXP1_0 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd0.I69._nr.MXPA1 _WD0.ROWSEL NXP0_0 _WD0.I69._NR.P1 VNWP P11LL_CKT
+  W=0.855U L=0.04U
X_M_wd0.I69._nr.MXPA2 _WD0.I69._NR.P1 NXP1_0 VDDP VNWP P11LL_CKT W=0.855U
+  L=0.04U
X_M_wd0._rowdrv_0.MXN10 NI0 ROWCLK0 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_M_wd0._rowdrv_0.MXN11 WL0 _WD0._ROWDRV_0.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_M_wd0._rowdrv_0.MXN8 _WD0._ROWDRV_0.NWL _WD0.ROWSEL NI0 VPW N11LL_CKT
+  W=1.02U L=0.04U
X_M_wd0._rowdrv_0.MXP1 WL0 _WD0._ROWDRV_0.NWL VDDC_L VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_M_wd0._rowdrv_0.MXP12 _WD0._ROWDRV_0.NWL ROWCLK0 VDDCE VNWC P11LL_CKT
+  W=0.77U L=0.04U
X_M_wd0._rowdrv_0.MXP13 _WD0._ROWDRV_0.NWL _WD0.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_M_wd0._rowdrv_1.MXN10 NI1 ROWCLK1 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_M_wd0._rowdrv_1.MXN11 WL1 _WD0._ROWDRV_1.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_M_wd0._rowdrv_1.MXN8 _WD0._ROWDRV_1.NWL _WD0.ROWSEL NI1 VPW N11LL_CKT
+  W=1.02U L=0.04U
X_M_wd0._rowdrv_1.MXP1 WL1 _WD0._ROWDRV_1.NWL VDDC_R VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_M_wd0._rowdrv_1.MXP12 _WD0._ROWDRV_1.NWL ROWCLK1 VDDCE VNWC P11LL_CKT
+  W=0.77U L=0.04U
X_M_wd0._rowdrv_1.MXP13 _WD0._ROWDRV_1.NWL _WD0.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_M_wd1.I69.MX_npd _WD1.ROWSEL DFTRAM_RET VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd1.I69.MX_nr_header VDDP DFTRAM_RET VDDPE VNWP P11LL_CKT W=0.855U L=0.04U
X_M_wd1.I69._nr.MXNA1 _WD1.ROWSEL NXP0_0 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd1.I69._nr.MXNA2 _WD1.ROWSEL NXP1_0 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd1.I69._nr.MXPA1 _WD1.ROWSEL NXP0_0 _WD1.I69._NR.P1 VNWP P11LL_CKT
+  W=0.855U L=0.04U
X_M_wd1.I69._nr.MXPA2 _WD1.I69._NR.P1 NXP1_0 VDDP VNWP P11LL_CKT W=0.855U
+  L=0.04U
X_M_wd1._rowdrv_0.MXN10 NI2 ROWCLK2 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_M_wd1._rowdrv_0.MXN11 WL2 _WD1._ROWDRV_0.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_M_wd1._rowdrv_0.MXN8 _WD1._ROWDRV_0.NWL _WD1.ROWSEL NI2 VPW N11LL_CKT
+  W=1.02U L=0.04U
X_M_wd1._rowdrv_0.MXP1 WL2 _WD1._ROWDRV_0.NWL VDDC_L VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_M_wd1._rowdrv_0.MXP12 _WD1._ROWDRV_0.NWL ROWCLK2 VDDCE VNWC P11LL_CKT
+  W=0.77U L=0.04U
X_M_wd1._rowdrv_0.MXP13 _WD1._ROWDRV_0.NWL _WD1.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_M_wd1._rowdrv_1.MXN10 NI3 ROWCLK3 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_M_wd1._rowdrv_1.MXN11 WL3 _WD1._ROWDRV_1.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_M_wd1._rowdrv_1.MXN8 _WD1._ROWDRV_1.NWL _WD1.ROWSEL NI3 VPW N11LL_CKT
+  W=1.02U L=0.04U
X_M_wd1._rowdrv_1.MXP1 WL3 _WD1._ROWDRV_1.NWL VDDC_R VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_M_wd1._rowdrv_1.MXP12 _WD1._ROWDRV_1.NWL ROWCLK3 VDDCE VNWC P11LL_CKT
+  W=0.77U L=0.04U
X_M_wd1._rowdrv_1.MXP13 _WD1._ROWDRV_1.NWL _WD1.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_M_wd10.I69.MX_npd _WD10.ROWSEL DFTRAM_RET VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd10.I69.MX_nr_header VDDP DFTRAM_RET VDDPE VNWP P11LL_CKT W=0.855U
+  L=0.04U
X_M_wd10.I69._nr.MXNA1 _WD10.ROWSEL NXP0_2 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd10.I69._nr.MXNA2 _WD10.ROWSEL NXP1_0 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd10.I69._nr.MXPA1 _WD10.ROWSEL NXP0_2 _WD10.I69._NR.P1 VNWP P11LL_CKT
+  W=0.855U L=0.04U
X_M_wd10.I69._nr.MXPA2 _WD10.I69._NR.P1 NXP1_0 VDDP VNWP P11LL_CKT W=0.855U
+  L=0.04U
X_M_wd10._rowdrv_0.MXN10 NI4 ROWCLK4 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_M_wd10._rowdrv_0.MXN11 WL20 _WD10._ROWDRV_0.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_M_wd10._rowdrv_0.MXN8 _WD10._ROWDRV_0.NWL _WD10.ROWSEL NI4 VPW N11LL_CKT
+  W=1.02U L=0.04U
X_M_wd10._rowdrv_0.MXP1 WL20 _WD10._ROWDRV_0.NWL VDDC_L VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_M_wd10._rowdrv_0.MXP12 _WD10._ROWDRV_0.NWL ROWCLK4 VDDCE VNWC P11LL_CKT
+  W=0.77U L=0.04U
X_M_wd10._rowdrv_0.MXP13 _WD10._ROWDRV_0.NWL _WD10.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_M_wd10._rowdrv_1.MXN10 NI5 ROWCLK5 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_M_wd10._rowdrv_1.MXN11 WL21 _WD10._ROWDRV_1.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_M_wd10._rowdrv_1.MXN8 _WD10._ROWDRV_1.NWL _WD10.ROWSEL NI5 VPW N11LL_CKT
+  W=1.02U L=0.04U
X_M_wd10._rowdrv_1.MXP1 WL21 _WD10._ROWDRV_1.NWL VDDC_R VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_M_wd10._rowdrv_1.MXP12 _WD10._ROWDRV_1.NWL ROWCLK5 VDDCE VNWC P11LL_CKT
+  W=0.77U L=0.04U
X_M_wd10._rowdrv_1.MXP13 _WD10._ROWDRV_1.NWL _WD10.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_M_wd11.I69.MX_npd _WD11.ROWSEL DFTRAM_RET VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd11.I69.MX_nr_header VDDP DFTRAM_RET VDDPE VNWP P11LL_CKT W=0.855U
+  L=0.04U
X_M_wd11.I69._nr.MXNA1 _WD11.ROWSEL NXP0_2 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd11.I69._nr.MXNA2 _WD11.ROWSEL NXP1_0 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd11.I69._nr.MXPA1 _WD11.ROWSEL NXP0_2 _WD11.I69._NR.P1 VNWP P11LL_CKT
+  W=0.855U L=0.04U
X_M_wd11.I69._nr.MXPA2 _WD11.I69._NR.P1 NXP1_0 VDDP VNWP P11LL_CKT W=0.855U
+  L=0.04U
X_M_wd11._rowdrv_0.MXN10 NI6 ROWCLK6 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_M_wd11._rowdrv_0.MXN11 WL22 _WD11._ROWDRV_0.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_M_wd11._rowdrv_0.MXN8 _WD11._ROWDRV_0.NWL _WD11.ROWSEL NI6 VPW N11LL_CKT
+  W=1.02U L=0.04U
X_M_wd11._rowdrv_0.MXP1 WL22 _WD11._ROWDRV_0.NWL VDDC_L VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_M_wd11._rowdrv_0.MXP12 _WD11._ROWDRV_0.NWL ROWCLK6 VDDCE VNWC P11LL_CKT
+  W=0.77U L=0.04U
X_M_wd11._rowdrv_0.MXP13 _WD11._ROWDRV_0.NWL _WD11.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_M_wd11._rowdrv_1.MXN10 NI7 ROWCLK7 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_M_wd11._rowdrv_1.MXN11 WL23 _WD11._ROWDRV_1.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_M_wd11._rowdrv_1.MXN8 _WD11._ROWDRV_1.NWL _WD11.ROWSEL NI7 VPW N11LL_CKT
+  W=1.02U L=0.04U
X_M_wd11._rowdrv_1.MXP1 WL23 _WD11._ROWDRV_1.NWL VDDC_R VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_M_wd11._rowdrv_1.MXP12 _WD11._ROWDRV_1.NWL ROWCLK7 VDDCE VNWC P11LL_CKT
+  W=0.77U L=0.04U
X_M_wd11._rowdrv_1.MXP13 _WD11._ROWDRV_1.NWL _WD11.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_M_wd12.I69.MX_npd _WD12.ROWSEL DFTRAM_RET VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd12.I69.MX_nr_header VDDP DFTRAM_RET VDDPE VNWP P11LL_CKT W=0.855U
+  L=0.04U
X_M_wd12.I69._nr.MXNA1 _WD12.ROWSEL NXP0_3 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd12.I69._nr.MXNA2 _WD12.ROWSEL NXP1_0 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd12.I69._nr.MXPA1 _WD12.ROWSEL NXP0_3 _WD12.I69._NR.P1 VNWP P11LL_CKT
+  W=0.855U L=0.04U
X_M_wd12.I69._nr.MXPA2 _WD12.I69._NR.P1 NXP1_0 VDDP VNWP P11LL_CKT W=0.855U
+  L=0.04U
X_M_wd12._rowdrv_0.MXN10 NI0 ROWCLK0 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_M_wd12._rowdrv_0.MXN11 WL24 _WD12._ROWDRV_0.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_M_wd12._rowdrv_0.MXN8 _WD12._ROWDRV_0.NWL _WD12.ROWSEL NI0 VPW N11LL_CKT
+  W=1.02U L=0.04U
X_M_wd12._rowdrv_0.MXP1 WL24 _WD12._ROWDRV_0.NWL VDDC_L VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_M_wd12._rowdrv_0.MXP12 _WD12._ROWDRV_0.NWL ROWCLK0 VDDCE VNWC P11LL_CKT
+  W=0.77U L=0.04U
X_M_wd12._rowdrv_0.MXP13 _WD12._ROWDRV_0.NWL _WD12.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_M_wd12._rowdrv_1.MXN10 NI1 ROWCLK1 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_M_wd12._rowdrv_1.MXN11 WL25 _WD12._ROWDRV_1.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_M_wd12._rowdrv_1.MXN8 _WD12._ROWDRV_1.NWL _WD12.ROWSEL NI1 VPW N11LL_CKT
+  W=1.02U L=0.04U
X_M_wd12._rowdrv_1.MXP1 WL25 _WD12._ROWDRV_1.NWL VDDC_R VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_M_wd12._rowdrv_1.MXP12 _WD12._ROWDRV_1.NWL ROWCLK1 VDDCE VNWC P11LL_CKT
+  W=0.77U L=0.04U
X_M_wd12._rowdrv_1.MXP13 _WD12._ROWDRV_1.NWL _WD12.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_M_wd13.I69.MX_npd _WD13.ROWSEL DFTRAM_RET VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd13.I69.MX_nr_header VDDP DFTRAM_RET VDDPE VNWP P11LL_CKT W=0.855U
+  L=0.04U
X_M_wd13.I69._nr.MXNA1 _WD13.ROWSEL NXP0_3 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd13.I69._nr.MXNA2 _WD13.ROWSEL NXP1_0 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd13.I69._nr.MXPA1 _WD13.ROWSEL NXP0_3 _WD13.I69._NR.P1 VNWP P11LL_CKT
+  W=0.855U L=0.04U
X_M_wd13.I69._nr.MXPA2 _WD13.I69._NR.P1 NXP1_0 VDDP VNWP P11LL_CKT W=0.855U
+  L=0.04U
X_M_wd13._rowdrv_0.MXN10 NI2 ROWCLK2 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_M_wd13._rowdrv_0.MXN11 WL26 _WD13._ROWDRV_0.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_M_wd13._rowdrv_0.MXN8 _WD13._ROWDRV_0.NWL _WD13.ROWSEL NI2 VPW N11LL_CKT
+  W=1.02U L=0.04U
X_M_wd13._rowdrv_0.MXP1 WL26 _WD13._ROWDRV_0.NWL VDDC_L VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_M_wd13._rowdrv_0.MXP12 _WD13._ROWDRV_0.NWL ROWCLK2 VDDCE VNWC P11LL_CKT
+  W=0.77U L=0.04U
X_M_wd13._rowdrv_0.MXP13 _WD13._ROWDRV_0.NWL _WD13.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_M_wd13._rowdrv_1.MXN10 NI3 ROWCLK3 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_M_wd13._rowdrv_1.MXN11 WL27 _WD13._ROWDRV_1.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_M_wd13._rowdrv_1.MXN8 _WD13._ROWDRV_1.NWL _WD13.ROWSEL NI3 VPW N11LL_CKT
+  W=1.02U L=0.04U
X_M_wd13._rowdrv_1.MXP1 WL27 _WD13._ROWDRV_1.NWL VDDC_R VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_M_wd13._rowdrv_1.MXP12 _WD13._ROWDRV_1.NWL ROWCLK3 VDDCE VNWC P11LL_CKT
+  W=0.77U L=0.04U
X_M_wd13._rowdrv_1.MXP13 _WD13._ROWDRV_1.NWL _WD13.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_M_wd14.I69.MX_npd _WD14.ROWSEL DFTRAM_RET VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd14.I69.MX_nr_header VDDP DFTRAM_RET VDDPE VNWP P11LL_CKT W=0.855U
+  L=0.04U
X_M_wd14.I69._nr.MXNA1 _WD14.ROWSEL NXP0_3 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd14.I69._nr.MXNA2 _WD14.ROWSEL NXP1_0 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd14.I69._nr.MXPA1 _WD14.ROWSEL NXP0_3 _WD14.I69._NR.P1 VNWP P11LL_CKT
+  W=0.855U L=0.04U
X_M_wd14.I69._nr.MXPA2 _WD14.I69._NR.P1 NXP1_0 VDDP VNWP P11LL_CKT W=0.855U
+  L=0.04U
X_M_wd14._rowdrv_0.MXN10 NI4 ROWCLK4 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_M_wd14._rowdrv_0.MXN11 WL28 _WD14._ROWDRV_0.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_M_wd14._rowdrv_0.MXN8 _WD14._ROWDRV_0.NWL _WD14.ROWSEL NI4 VPW N11LL_CKT
+  W=1.02U L=0.04U
X_M_wd14._rowdrv_0.MXP1 WL28 _WD14._ROWDRV_0.NWL VDDC_L VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_M_wd14._rowdrv_0.MXP12 _WD14._ROWDRV_0.NWL ROWCLK4 VDDCE VNWC P11LL_CKT
+  W=0.77U L=0.04U
X_M_wd14._rowdrv_0.MXP13 _WD14._ROWDRV_0.NWL _WD14.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_M_wd14._rowdrv_1.MXN10 NI5 ROWCLK5 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_M_wd14._rowdrv_1.MXN11 WL29 _WD14._ROWDRV_1.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_M_wd14._rowdrv_1.MXN8 _WD14._ROWDRV_1.NWL _WD14.ROWSEL NI5 VPW N11LL_CKT
+  W=1.02U L=0.04U
X_M_wd14._rowdrv_1.MXP1 WL29 _WD14._ROWDRV_1.NWL VDDC_R VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_M_wd14._rowdrv_1.MXP12 _WD14._ROWDRV_1.NWL ROWCLK5 VDDCE VNWC P11LL_CKT
+  W=0.77U L=0.04U
X_M_wd14._rowdrv_1.MXP13 _WD14._ROWDRV_1.NWL _WD14.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_M_wd15.I69.MX_npd _WD15.ROWSEL DFTRAM_RET VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd15.I69.MX_nr_header VDDP DFTRAM_RET VDDPE VNWP P11LL_CKT W=0.855U
+  L=0.04U
X_M_wd15.I69._nr.MXNA1 _WD15.ROWSEL NXP0_3 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd15.I69._nr.MXNA2 _WD15.ROWSEL NXP1_0 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd15.I69._nr.MXPA1 _WD15.ROWSEL NXP0_3 _WD15.I69._NR.P1 VNWP P11LL_CKT
+  W=0.855U L=0.04U
X_M_wd15.I69._nr.MXPA2 _WD15.I69._NR.P1 NXP1_0 VDDP VNWP P11LL_CKT W=0.855U
+  L=0.04U
X_M_wd15._rowdrv_0.MXN10 NI6 ROWCLK6 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_M_wd15._rowdrv_0.MXN11 WL30 _WD15._ROWDRV_0.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_M_wd15._rowdrv_0.MXN8 _WD15._ROWDRV_0.NWL _WD15.ROWSEL NI6 VPW N11LL_CKT
+  W=1.02U L=0.04U
X_M_wd15._rowdrv_0.MXP1 WL30 _WD15._ROWDRV_0.NWL VDDC_L VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_M_wd15._rowdrv_0.MXP12 _WD15._ROWDRV_0.NWL ROWCLK6 VDDCE VNWC P11LL_CKT
+  W=0.77U L=0.04U
X_M_wd15._rowdrv_0.MXP13 _WD15._ROWDRV_0.NWL _WD15.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_M_wd15._rowdrv_1.MXN10 NI7 ROWCLK7 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_M_wd15._rowdrv_1.MXN11 WL31 _WD15._ROWDRV_1.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_M_wd15._rowdrv_1.MXN8 _WD15._ROWDRV_1.NWL _WD15.ROWSEL NI7 VPW N11LL_CKT
+  W=1.02U L=0.04U
X_M_wd15._rowdrv_1.MXP1 WL31 _WD15._ROWDRV_1.NWL VDDC_R VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_M_wd15._rowdrv_1.MXP12 _WD15._ROWDRV_1.NWL ROWCLK7 VDDCE VNWC P11LL_CKT
+  W=0.77U L=0.04U
X_M_wd15._rowdrv_1.MXP13 _WD15._ROWDRV_1.NWL _WD15.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_M_wd2.I69.MX_npd _WD2.ROWSEL DFTRAM_RET VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd2.I69.MX_nr_header VDDP DFTRAM_RET VDDPE VNWP P11LL_CKT W=0.855U L=0.04U
X_M_wd2.I69._nr.MXNA1 _WD2.ROWSEL NXP0_0 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd2.I69._nr.MXNA2 _WD2.ROWSEL NXP1_0 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd2.I69._nr.MXPA1 _WD2.ROWSEL NXP0_0 _WD2.I69._NR.P1 VNWP P11LL_CKT
+  W=0.855U L=0.04U
X_M_wd2.I69._nr.MXPA2 _WD2.I69._NR.P1 NXP1_0 VDDP VNWP P11LL_CKT W=0.855U
+  L=0.04U
X_M_wd2._rowdrv_0.MXN10 NI4 ROWCLK4 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_M_wd2._rowdrv_0.MXN11 WL4 _WD2._ROWDRV_0.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_M_wd2._rowdrv_0.MXN8 _WD2._ROWDRV_0.NWL _WD2.ROWSEL NI4 VPW N11LL_CKT
+  W=1.02U L=0.04U
X_M_wd2._rowdrv_0.MXP1 WL4 _WD2._ROWDRV_0.NWL VDDC_L VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_M_wd2._rowdrv_0.MXP12 _WD2._ROWDRV_0.NWL ROWCLK4 VDDCE VNWC P11LL_CKT
+  W=0.77U L=0.04U
X_M_wd2._rowdrv_0.MXP13 _WD2._ROWDRV_0.NWL _WD2.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_M_wd2._rowdrv_1.MXN10 NI5 ROWCLK5 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_M_wd2._rowdrv_1.MXN11 WL5 _WD2._ROWDRV_1.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_M_wd2._rowdrv_1.MXN8 _WD2._ROWDRV_1.NWL _WD2.ROWSEL NI5 VPW N11LL_CKT
+  W=1.02U L=0.04U
X_M_wd2._rowdrv_1.MXP1 WL5 _WD2._ROWDRV_1.NWL VDDC_R VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_M_wd2._rowdrv_1.MXP12 _WD2._ROWDRV_1.NWL ROWCLK5 VDDCE VNWC P11LL_CKT
+  W=0.77U L=0.04U
X_M_wd2._rowdrv_1.MXP13 _WD2._ROWDRV_1.NWL _WD2.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_M_wd3.I69.MX_npd _WD3.ROWSEL DFTRAM_RET VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd3.I69.MX_nr_header VDDP DFTRAM_RET VDDPE VNWP P11LL_CKT W=0.855U L=0.04U
X_M_wd3.I69._nr.MXNA1 _WD3.ROWSEL NXP0_0 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd3.I69._nr.MXNA2 _WD3.ROWSEL NXP1_0 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd3.I69._nr.MXPA1 _WD3.ROWSEL NXP0_0 _WD3.I69._NR.P1 VNWP P11LL_CKT
+  W=0.855U L=0.04U
X_M_wd3.I69._nr.MXPA2 _WD3.I69._NR.P1 NXP1_0 VDDP VNWP P11LL_CKT W=0.855U
+  L=0.04U
X_M_wd3._rowdrv_0.MXN10 NI6 ROWCLK6 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_M_wd3._rowdrv_0.MXN11 WL6 _WD3._ROWDRV_0.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_M_wd3._rowdrv_0.MXN8 _WD3._ROWDRV_0.NWL _WD3.ROWSEL NI6 VPW N11LL_CKT
+  W=1.02U L=0.04U
X_M_wd3._rowdrv_0.MXP1 WL6 _WD3._ROWDRV_0.NWL VDDC_L VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_M_wd3._rowdrv_0.MXP12 _WD3._ROWDRV_0.NWL ROWCLK6 VDDCE VNWC P11LL_CKT
+  W=0.77U L=0.04U
X_M_wd3._rowdrv_0.MXP13 _WD3._ROWDRV_0.NWL _WD3.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_M_wd3._rowdrv_1.MXN10 NI7 ROWCLK7 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_M_wd3._rowdrv_1.MXN11 WL7 _WD3._ROWDRV_1.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_M_wd3._rowdrv_1.MXN8 _WD3._ROWDRV_1.NWL _WD3.ROWSEL NI7 VPW N11LL_CKT
+  W=1.02U L=0.04U
X_M_wd3._rowdrv_1.MXP1 WL7 _WD3._ROWDRV_1.NWL VDDC_R VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_M_wd3._rowdrv_1.MXP12 _WD3._ROWDRV_1.NWL ROWCLK7 VDDCE VNWC P11LL_CKT
+  W=0.77U L=0.04U
X_M_wd3._rowdrv_1.MXP13 _WD3._ROWDRV_1.NWL _WD3.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_M_wd4.I69.MX_npd _WD4.ROWSEL DFTRAM_RET VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd4.I69.MX_nr_header VDDP DFTRAM_RET VDDPE VNWP P11LL_CKT W=0.855U L=0.04U
X_M_wd4.I69._nr.MXNA1 _WD4.ROWSEL NXP0_1 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd4.I69._nr.MXNA2 _WD4.ROWSEL NXP1_0 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd4.I69._nr.MXPA1 _WD4.ROWSEL NXP0_1 _WD4.I69._NR.P1 VNWP P11LL_CKT
+  W=0.855U L=0.04U
X_M_wd4.I69._nr.MXPA2 _WD4.I69._NR.P1 NXP1_0 VDDP VNWP P11LL_CKT W=0.855U
+  L=0.04U
X_M_wd4._rowdrv_0.MXN10 NI0 ROWCLK0 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_M_wd4._rowdrv_0.MXN11 WL8 _WD4._ROWDRV_0.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_M_wd4._rowdrv_0.MXN8 _WD4._ROWDRV_0.NWL _WD4.ROWSEL NI0 VPW N11LL_CKT
+  W=1.02U L=0.04U
X_M_wd4._rowdrv_0.MXP1 WL8 _WD4._ROWDRV_0.NWL VDDC_L VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_M_wd4._rowdrv_0.MXP12 _WD4._ROWDRV_0.NWL ROWCLK0 VDDCE VNWC P11LL_CKT
+  W=0.77U L=0.04U
X_M_wd4._rowdrv_0.MXP13 _WD4._ROWDRV_0.NWL _WD4.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_M_wd4._rowdrv_1.MXN10 NI1 ROWCLK1 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_M_wd4._rowdrv_1.MXN11 WL9 _WD4._ROWDRV_1.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_M_wd4._rowdrv_1.MXN8 _WD4._ROWDRV_1.NWL _WD4.ROWSEL NI1 VPW N11LL_CKT
+  W=1.02U L=0.04U
X_M_wd4._rowdrv_1.MXP1 WL9 _WD4._ROWDRV_1.NWL VDDC_R VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_M_wd4._rowdrv_1.MXP12 _WD4._ROWDRV_1.NWL ROWCLK1 VDDCE VNWC P11LL_CKT
+  W=0.77U L=0.04U
X_M_wd4._rowdrv_1.MXP13 _WD4._ROWDRV_1.NWL _WD4.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_M_wd5.I69.MX_npd _WD5.ROWSEL DFTRAM_RET VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd5.I69.MX_nr_header VDDP DFTRAM_RET VDDPE VNWP P11LL_CKT W=0.855U L=0.04U
X_M_wd5.I69._nr.MXNA1 _WD5.ROWSEL NXP0_1 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd5.I69._nr.MXNA2 _WD5.ROWSEL NXP1_0 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd5.I69._nr.MXPA1 _WD5.ROWSEL NXP0_1 _WD5.I69._NR.P1 VNWP P11LL_CKT
+  W=0.855U L=0.04U
X_M_wd5.I69._nr.MXPA2 _WD5.I69._NR.P1 NXP1_0 VDDP VNWP P11LL_CKT W=0.855U
+  L=0.04U
X_M_wd5._rowdrv_0.MXN10 NI2 ROWCLK2 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_M_wd5._rowdrv_0.MXN11 WL10 _WD5._ROWDRV_0.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_M_wd5._rowdrv_0.MXN8 _WD5._ROWDRV_0.NWL _WD5.ROWSEL NI2 VPW N11LL_CKT
+  W=1.02U L=0.04U
X_M_wd5._rowdrv_0.MXP1 WL10 _WD5._ROWDRV_0.NWL VDDC_L VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_M_wd5._rowdrv_0.MXP12 _WD5._ROWDRV_0.NWL ROWCLK2 VDDCE VNWC P11LL_CKT
+  W=0.77U L=0.04U
X_M_wd5._rowdrv_0.MXP13 _WD5._ROWDRV_0.NWL _WD5.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_M_wd5._rowdrv_1.MXN10 NI3 ROWCLK3 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_M_wd5._rowdrv_1.MXN11 WL11 _WD5._ROWDRV_1.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_M_wd5._rowdrv_1.MXN8 _WD5._ROWDRV_1.NWL _WD5.ROWSEL NI3 VPW N11LL_CKT
+  W=1.02U L=0.04U
X_M_wd5._rowdrv_1.MXP1 WL11 _WD5._ROWDRV_1.NWL VDDC_R VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_M_wd5._rowdrv_1.MXP12 _WD5._ROWDRV_1.NWL ROWCLK3 VDDCE VNWC P11LL_CKT
+  W=0.77U L=0.04U
X_M_wd5._rowdrv_1.MXP13 _WD5._ROWDRV_1.NWL _WD5.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_M_wd54.I69.MX_npd _WD54.ROWSEL DFTRAM_RET VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd54.I69.MX_nr_header VDDP DFTRAM_RET VDDPE VNWP P11LL_CKT W=0.855U
+  L=0.04U
X_M_wd54.I69._nr.MXNA1 _WD54.ROWSEL NXP0_5 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd54.I69._nr.MXNA2 _WD54.ROWSEL NXP1_0 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd54.I69._nr.MXPA1 _WD54.ROWSEL NXP0_5 _WD54.I69._NR.P1 VNWP P11LL_CKT
+  W=0.855U L=0.04U
X_M_wd54.I69._nr.MXPA2 _WD54.I69._NR.P1 NXP1_0 VDDP VNWP P11LL_CKT W=0.855U
+  L=0.04U
X_M_wd54._rowdrv_0.MXN10 NI4 ROWCLK4 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_M_wd54._rowdrv_0.MXN11 WL44 _WD54._ROWDRV_0.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_M_wd54._rowdrv_0.MXN8 _WD54._ROWDRV_0.NWL _WD54.ROWSEL NI4 VPW N11LL_CKT
+  W=1.02U L=0.04U
X_M_wd54._rowdrv_0.MXP1 WL44 _WD54._ROWDRV_0.NWL VDDC_L VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_M_wd54._rowdrv_0.MXP12 _WD54._ROWDRV_0.NWL ROWCLK4 VDDCE VNWC P11LL_CKT
+  W=0.77U L=0.04U
X_M_wd54._rowdrv_0.MXP13 _WD54._ROWDRV_0.NWL _WD54.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_M_wd54._rowdrv_1.MXN10 NI5 ROWCLK5 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_M_wd54._rowdrv_1.MXN11 WL45 _WD54._ROWDRV_1.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_M_wd54._rowdrv_1.MXN8 _WD54._ROWDRV_1.NWL _WD54.ROWSEL NI5 VPW N11LL_CKT
+  W=1.02U L=0.04U
X_M_wd54._rowdrv_1.MXP1 WL45 _WD54._ROWDRV_1.NWL VDDC_R VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_M_wd54._rowdrv_1.MXP12 _WD54._ROWDRV_1.NWL ROWCLK5 VDDCE VNWC P11LL_CKT
+  W=0.77U L=0.04U
X_M_wd54._rowdrv_1.MXP13 _WD54._ROWDRV_1.NWL _WD54.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_M_wd55.I69.MX_npd _WD55.ROWSEL DFTRAM_RET VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd55.I69.MX_nr_header VDDP DFTRAM_RET VDDPE VNWP P11LL_CKT W=0.855U
+  L=0.04U
X_M_wd55.I69._nr.MXNA1 _WD55.ROWSEL NXP0_5 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd55.I69._nr.MXNA2 _WD55.ROWSEL NXP1_0 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd55.I69._nr.MXPA1 _WD55.ROWSEL NXP0_5 _WD55.I69._NR.P1 VNWP P11LL_CKT
+  W=0.855U L=0.04U
X_M_wd55.I69._nr.MXPA2 _WD55.I69._NR.P1 NXP1_0 VDDP VNWP P11LL_CKT W=0.855U
+  L=0.04U
X_M_wd55._rowdrv_0.MXN10 NI6 ROWCLK6 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_M_wd55._rowdrv_0.MXN11 WL46 _WD55._ROWDRV_0.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_M_wd55._rowdrv_0.MXN8 _WD55._ROWDRV_0.NWL _WD55.ROWSEL NI6 VPW N11LL_CKT
+  W=1.02U L=0.04U
X_M_wd55._rowdrv_0.MXP1 WL46 _WD55._ROWDRV_0.NWL VDDC_L VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_M_wd55._rowdrv_0.MXP12 _WD55._ROWDRV_0.NWL ROWCLK6 VDDCE VNWC P11LL_CKT
+  W=0.77U L=0.04U
X_M_wd55._rowdrv_0.MXP13 _WD55._ROWDRV_0.NWL _WD55.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_M_wd55._rowdrv_1.MXN10 NI7 ROWCLK7 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_M_wd55._rowdrv_1.MXN11 WL47 _WD55._ROWDRV_1.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_M_wd55._rowdrv_1.MXN8 _WD55._ROWDRV_1.NWL _WD55.ROWSEL NI7 VPW N11LL_CKT
+  W=1.02U L=0.04U
X_M_wd55._rowdrv_1.MXP1 WL47 _WD55._ROWDRV_1.NWL VDDC_R VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_M_wd55._rowdrv_1.MXP12 _WD55._ROWDRV_1.NWL ROWCLK7 VDDCE VNWC P11LL_CKT
+  W=0.77U L=0.04U
X_M_wd55._rowdrv_1.MXP13 _WD55._ROWDRV_1.NWL _WD55.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_M_wd56.I69.MX_npd _WD56.ROWSEL DFTRAM_RET VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd56.I69.MX_nr_header VDDP DFTRAM_RET VDDPE VNWP P11LL_CKT W=0.855U
+  L=0.04U
X_M_wd56.I69._nr.MXNA1 _WD56.ROWSEL NXP0_6 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd56.I69._nr.MXNA2 _WD56.ROWSEL NXP1_0 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd56.I69._nr.MXPA1 _WD56.ROWSEL NXP0_6 _WD56.I69._NR.P1 VNWP P11LL_CKT
+  W=0.855U L=0.04U
X_M_wd56.I69._nr.MXPA2 _WD56.I69._NR.P1 NXP1_0 VDDP VNWP P11LL_CKT W=0.855U
+  L=0.04U
X_M_wd56._rowdrv_0.MXN10 NI0 ROWCLK0 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_M_wd56._rowdrv_0.MXN11 WL48 _WD56._ROWDRV_0.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_M_wd56._rowdrv_0.MXN8 _WD56._ROWDRV_0.NWL _WD56.ROWSEL NI0 VPW N11LL_CKT
+  W=1.02U L=0.04U
X_M_wd56._rowdrv_0.MXP1 WL48 _WD56._ROWDRV_0.NWL VDDC_L VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_M_wd56._rowdrv_0.MXP12 _WD56._ROWDRV_0.NWL ROWCLK0 VDDCE VNWC P11LL_CKT
+  W=0.77U L=0.04U
X_M_wd56._rowdrv_0.MXP13 _WD56._ROWDRV_0.NWL _WD56.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_M_wd56._rowdrv_1.MXN10 NI1 ROWCLK1 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_M_wd56._rowdrv_1.MXN11 WL49 _WD56._ROWDRV_1.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_M_wd56._rowdrv_1.MXN8 _WD56._ROWDRV_1.NWL _WD56.ROWSEL NI1 VPW N11LL_CKT
+  W=1.02U L=0.04U
X_M_wd56._rowdrv_1.MXP1 WL49 _WD56._ROWDRV_1.NWL VDDC_R VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_M_wd56._rowdrv_1.MXP12 _WD56._ROWDRV_1.NWL ROWCLK1 VDDCE VNWC P11LL_CKT
+  W=0.77U L=0.04U
X_M_wd56._rowdrv_1.MXP13 _WD56._ROWDRV_1.NWL _WD56.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_M_wd57.I69.MX_npd _WD57.ROWSEL DFTRAM_RET VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd57.I69.MX_nr_header VDDP DFTRAM_RET VDDPE VNWP P11LL_CKT W=0.855U
+  L=0.04U
X_M_wd57.I69._nr.MXNA1 _WD57.ROWSEL NXP0_6 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd57.I69._nr.MXNA2 _WD57.ROWSEL NXP1_0 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd57.I69._nr.MXPA1 _WD57.ROWSEL NXP0_6 _WD57.I69._NR.P1 VNWP P11LL_CKT
+  W=0.855U L=0.04U
X_M_wd57.I69._nr.MXPA2 _WD57.I69._NR.P1 NXP1_0 VDDP VNWP P11LL_CKT W=0.855U
+  L=0.04U
X_M_wd57._rowdrv_0.MXN10 NI2 ROWCLK2 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_M_wd57._rowdrv_0.MXN11 WL50 _WD57._ROWDRV_0.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_M_wd57._rowdrv_0.MXN8 _WD57._ROWDRV_0.NWL _WD57.ROWSEL NI2 VPW N11LL_CKT
+  W=1.02U L=0.04U
X_M_wd57._rowdrv_0.MXP1 WL50 _WD57._ROWDRV_0.NWL VDDC_L VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_M_wd57._rowdrv_0.MXP12 _WD57._ROWDRV_0.NWL ROWCLK2 VDDCE VNWC P11LL_CKT
+  W=0.77U L=0.04U
X_M_wd57._rowdrv_0.MXP13 _WD57._ROWDRV_0.NWL _WD57.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_M_wd57._rowdrv_1.MXN10 NI3 ROWCLK3 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_M_wd57._rowdrv_1.MXN11 WL51 _WD57._ROWDRV_1.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_M_wd57._rowdrv_1.MXN8 _WD57._ROWDRV_1.NWL _WD57.ROWSEL NI3 VPW N11LL_CKT
+  W=1.02U L=0.04U
X_M_wd57._rowdrv_1.MXP1 WL51 _WD57._ROWDRV_1.NWL VDDC_R VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_M_wd57._rowdrv_1.MXP12 _WD57._ROWDRV_1.NWL ROWCLK3 VDDCE VNWC P11LL_CKT
+  W=0.77U L=0.04U
X_M_wd57._rowdrv_1.MXP13 _WD57._ROWDRV_1.NWL _WD57.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_M_wd58.I69.MX_npd _WD58.ROWSEL DFTRAM_RET VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd58.I69.MX_nr_header VDDP DFTRAM_RET VDDPE VNWP P11LL_CKT W=0.855U
+  L=0.04U
X_M_wd58.I69._nr.MXNA1 _WD58.ROWSEL NXP0_6 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd58.I69._nr.MXNA2 _WD58.ROWSEL NXP1_0 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd58.I69._nr.MXPA1 _WD58.ROWSEL NXP0_6 _WD58.I69._NR.P1 VNWP P11LL_CKT
+  W=0.855U L=0.04U
X_M_wd58.I69._nr.MXPA2 _WD58.I69._NR.P1 NXP1_0 VDDP VNWP P11LL_CKT W=0.855U
+  L=0.04U
X_M_wd58._rowdrv_0.MXN10 NI4 ROWCLK4 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_M_wd58._rowdrv_0.MXN11 WL52 _WD58._ROWDRV_0.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_M_wd58._rowdrv_0.MXN8 _WD58._ROWDRV_0.NWL _WD58.ROWSEL NI4 VPW N11LL_CKT
+  W=1.02U L=0.04U
X_M_wd58._rowdrv_0.MXP1 WL52 _WD58._ROWDRV_0.NWL VDDC_L VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_M_wd58._rowdrv_0.MXP12 _WD58._ROWDRV_0.NWL ROWCLK4 VDDCE VNWC P11LL_CKT
+  W=0.77U L=0.04U
X_M_wd58._rowdrv_0.MXP13 _WD58._ROWDRV_0.NWL _WD58.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_M_wd58._rowdrv_1.MXN10 NI5 ROWCLK5 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_M_wd58._rowdrv_1.MXN11 WL53 _WD58._ROWDRV_1.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_M_wd58._rowdrv_1.MXN8 _WD58._ROWDRV_1.NWL _WD58.ROWSEL NI5 VPW N11LL_CKT
+  W=1.02U L=0.04U
X_M_wd58._rowdrv_1.MXP1 WL53 _WD58._ROWDRV_1.NWL VDDC_R VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_M_wd58._rowdrv_1.MXP12 _WD58._ROWDRV_1.NWL ROWCLK5 VDDCE VNWC P11LL_CKT
+  W=0.77U L=0.04U
X_M_wd58._rowdrv_1.MXP13 _WD58._ROWDRV_1.NWL _WD58.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_M_wd59.I69.MX_npd _WD59.ROWSEL DFTRAM_RET VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd59.I69.MX_nr_header VDDP DFTRAM_RET VDDPE VNWP P11LL_CKT W=0.855U
+  L=0.04U
X_M_wd59.I69._nr.MXNA1 _WD59.ROWSEL NXP0_6 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd59.I69._nr.MXNA2 _WD59.ROWSEL NXP1_0 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd59.I69._nr.MXPA1 _WD59.ROWSEL NXP0_6 _WD59.I69._NR.P1 VNWP P11LL_CKT
+  W=0.855U L=0.04U
X_M_wd59.I69._nr.MXPA2 _WD59.I69._NR.P1 NXP1_0 VDDP VNWP P11LL_CKT W=0.855U
+  L=0.04U
X_M_wd59._rowdrv_0.MXN10 NI6 ROWCLK6 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_M_wd59._rowdrv_0.MXN11 WL54 _WD59._ROWDRV_0.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_M_wd59._rowdrv_0.MXN8 _WD59._ROWDRV_0.NWL _WD59.ROWSEL NI6 VPW N11LL_CKT
+  W=1.02U L=0.04U
X_M_wd59._rowdrv_0.MXP1 WL54 _WD59._ROWDRV_0.NWL VDDC_L VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_M_wd59._rowdrv_0.MXP12 _WD59._ROWDRV_0.NWL ROWCLK6 VDDCE VNWC P11LL_CKT
+  W=0.77U L=0.04U
X_M_wd59._rowdrv_0.MXP13 _WD59._ROWDRV_0.NWL _WD59.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_M_wd59._rowdrv_1.MXN10 NI7 ROWCLK7 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_M_wd59._rowdrv_1.MXN11 WL55 _WD59._ROWDRV_1.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_M_wd59._rowdrv_1.MXN8 _WD59._ROWDRV_1.NWL _WD59.ROWSEL NI7 VPW N11LL_CKT
+  W=1.02U L=0.04U
X_M_wd59._rowdrv_1.MXP1 WL55 _WD59._ROWDRV_1.NWL VDDC_R VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_M_wd59._rowdrv_1.MXP12 _WD59._ROWDRV_1.NWL ROWCLK7 VDDCE VNWC P11LL_CKT
+  W=0.77U L=0.04U
X_M_wd59._rowdrv_1.MXP13 _WD59._ROWDRV_1.NWL _WD59.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_M_wd6.I69.MX_npd _WD6.ROWSEL DFTRAM_RET VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd6.I69.MX_nr_header VDDP DFTRAM_RET VDDPE VNWP P11LL_CKT W=0.855U L=0.04U
X_M_wd6.I69._nr.MXNA1 _WD6.ROWSEL NXP0_1 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd6.I69._nr.MXNA2 _WD6.ROWSEL NXP1_0 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd6.I69._nr.MXPA1 _WD6.ROWSEL NXP0_1 _WD6.I69._NR.P1 VNWP P11LL_CKT
+  W=0.855U L=0.04U
X_M_wd6.I69._nr.MXPA2 _WD6.I69._NR.P1 NXP1_0 VDDP VNWP P11LL_CKT W=0.855U
+  L=0.04U
X_M_wd6._rowdrv_0.MXN10 NI4 ROWCLK4 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_M_wd6._rowdrv_0.MXN11 WL12 _WD6._ROWDRV_0.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_M_wd6._rowdrv_0.MXN8 _WD6._ROWDRV_0.NWL _WD6.ROWSEL NI4 VPW N11LL_CKT
+  W=1.02U L=0.04U
X_M_wd6._rowdrv_0.MXP1 WL12 _WD6._ROWDRV_0.NWL VDDC_L VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_M_wd6._rowdrv_0.MXP12 _WD6._ROWDRV_0.NWL ROWCLK4 VDDCE VNWC P11LL_CKT
+  W=0.77U L=0.04U
X_M_wd6._rowdrv_0.MXP13 _WD6._ROWDRV_0.NWL _WD6.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_M_wd6._rowdrv_1.MXN10 NI5 ROWCLK5 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_M_wd6._rowdrv_1.MXN11 WL13 _WD6._ROWDRV_1.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_M_wd6._rowdrv_1.MXN8 _WD6._ROWDRV_1.NWL _WD6.ROWSEL NI5 VPW N11LL_CKT
+  W=1.02U L=0.04U
X_M_wd6._rowdrv_1.MXP1 WL13 _WD6._ROWDRV_1.NWL VDDC_R VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_M_wd6._rowdrv_1.MXP12 _WD6._ROWDRV_1.NWL ROWCLK5 VDDCE VNWC P11LL_CKT
+  W=0.77U L=0.04U
X_M_wd6._rowdrv_1.MXP13 _WD6._ROWDRV_1.NWL _WD6.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_M_wd60.I69.MX_npd _WD60.ROWSEL DFTRAM_RET VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd60.I69.MX_nr_header VDDP DFTRAM_RET VDDPE VNWP P11LL_CKT W=0.855U
+  L=0.04U
X_M_wd60.I69._nr.MXNA1 _WD60.ROWSEL NXP0_7 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd60.I69._nr.MXNA2 _WD60.ROWSEL NXP1_0 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd60.I69._nr.MXPA1 _WD60.ROWSEL NXP0_7 _WD60.I69._NR.P1 VNWP P11LL_CKT
+  W=0.855U L=0.04U
X_M_wd60.I69._nr.MXPA2 _WD60.I69._NR.P1 NXP1_0 VDDP VNWP P11LL_CKT W=0.855U
+  L=0.04U
X_M_wd60._rowdrv_0.MXN10 NI0 ROWCLK0 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_M_wd60._rowdrv_0.MXN11 WL56 _WD60._ROWDRV_0.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_M_wd60._rowdrv_0.MXN8 _WD60._ROWDRV_0.NWL _WD60.ROWSEL NI0 VPW N11LL_CKT
+  W=1.02U L=0.04U
X_M_wd60._rowdrv_0.MXP1 WL56 _WD60._ROWDRV_0.NWL VDDC_L VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_M_wd60._rowdrv_0.MXP12 _WD60._ROWDRV_0.NWL ROWCLK0 VDDCE VNWC P11LL_CKT
+  W=0.77U L=0.04U
X_M_wd60._rowdrv_0.MXP13 _WD60._ROWDRV_0.NWL _WD60.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_M_wd60._rowdrv_1.MXN10 NI1 ROWCLK1 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_M_wd60._rowdrv_1.MXN11 WL57 _WD60._ROWDRV_1.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_M_wd60._rowdrv_1.MXN8 _WD60._ROWDRV_1.NWL _WD60.ROWSEL NI1 VPW N11LL_CKT
+  W=1.02U L=0.04U
X_M_wd60._rowdrv_1.MXP1 WL57 _WD60._ROWDRV_1.NWL VDDC_R VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_M_wd60._rowdrv_1.MXP12 _WD60._ROWDRV_1.NWL ROWCLK1 VDDCE VNWC P11LL_CKT
+  W=0.77U L=0.04U
X_M_wd60._rowdrv_1.MXP13 _WD60._ROWDRV_1.NWL _WD60.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_M_wd61.I69.MX_npd _WD61.ROWSEL DFTRAM_RET VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd61.I69.MX_nr_header VDDP DFTRAM_RET VDDPE VNWP P11LL_CKT W=0.855U
+  L=0.04U
X_M_wd61.I69._nr.MXNA1 _WD61.ROWSEL NXP0_7 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd61.I69._nr.MXNA2 _WD61.ROWSEL NXP1_0 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd61.I69._nr.MXPA1 _WD61.ROWSEL NXP0_7 _WD61.I69._NR.P1 VNWP P11LL_CKT
+  W=0.855U L=0.04U
X_M_wd61.I69._nr.MXPA2 _WD61.I69._NR.P1 NXP1_0 VDDP VNWP P11LL_CKT W=0.855U
+  L=0.04U
X_M_wd61._rowdrv_0.MXN10 NI2 ROWCLK2 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_M_wd61._rowdrv_0.MXN11 WL58 _WD61._ROWDRV_0.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_M_wd61._rowdrv_0.MXN8 _WD61._ROWDRV_0.NWL _WD61.ROWSEL NI2 VPW N11LL_CKT
+  W=1.02U L=0.04U
X_M_wd61._rowdrv_0.MXP1 WL58 _WD61._ROWDRV_0.NWL VDDC_L VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_M_wd61._rowdrv_0.MXP12 _WD61._ROWDRV_0.NWL ROWCLK2 VDDCE VNWC P11LL_CKT
+  W=0.77U L=0.04U
X_M_wd61._rowdrv_0.MXP13 _WD61._ROWDRV_0.NWL _WD61.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_M_wd61._rowdrv_1.MXN10 NI3 ROWCLK3 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_M_wd61._rowdrv_1.MXN11 WL59 _WD61._ROWDRV_1.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_M_wd61._rowdrv_1.MXN8 _WD61._ROWDRV_1.NWL _WD61.ROWSEL NI3 VPW N11LL_CKT
+  W=1.02U L=0.04U
X_M_wd61._rowdrv_1.MXP1 WL59 _WD61._ROWDRV_1.NWL VDDC_R VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_M_wd61._rowdrv_1.MXP12 _WD61._ROWDRV_1.NWL ROWCLK3 VDDCE VNWC P11LL_CKT
+  W=0.77U L=0.04U
X_M_wd61._rowdrv_1.MXP13 _WD61._ROWDRV_1.NWL _WD61.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_M_wd62.I69.MX_npd _WD62.ROWSEL DFTRAM_RET VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd62.I69.MX_nr_header VDDP DFTRAM_RET VDDPE VNWP P11LL_CKT W=0.855U
+  L=0.04U
X_M_wd62.I69._nr.MXNA1 _WD62.ROWSEL NXP0_7 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd62.I69._nr.MXNA2 _WD62.ROWSEL NXP1_0 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd62.I69._nr.MXPA1 _WD62.ROWSEL NXP0_7 _WD62.I69._NR.P1 VNWP P11LL_CKT
+  W=0.855U L=0.04U
X_M_wd62.I69._nr.MXPA2 _WD62.I69._NR.P1 NXP1_0 VDDP VNWP P11LL_CKT W=0.855U
+  L=0.04U
X_M_wd62._rowdrv_0.MXN10 NI4 ROWCLK4 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_M_wd62._rowdrv_0.MXN11 WL60 _WD62._ROWDRV_0.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_M_wd62._rowdrv_0.MXN8 _WD62._ROWDRV_0.NWL _WD62.ROWSEL NI4 VPW N11LL_CKT
+  W=1.02U L=0.04U
X_M_wd62._rowdrv_0.MXP1 WL60 _WD62._ROWDRV_0.NWL VDDC_L VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_M_wd62._rowdrv_0.MXP12 _WD62._ROWDRV_0.NWL ROWCLK4 VDDCE VNWC P11LL_CKT
+  W=0.77U L=0.04U
X_M_wd62._rowdrv_0.MXP13 _WD62._ROWDRV_0.NWL _WD62.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_M_wd62._rowdrv_1.MXN10 NI5 ROWCLK5 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_M_wd62._rowdrv_1.MXN11 WL61 _WD62._ROWDRV_1.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_M_wd62._rowdrv_1.MXN8 _WD62._ROWDRV_1.NWL _WD62.ROWSEL NI5 VPW N11LL_CKT
+  W=1.02U L=0.04U
X_M_wd62._rowdrv_1.MXP1 WL61 _WD62._ROWDRV_1.NWL VDDC_R VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_M_wd62._rowdrv_1.MXP12 _WD62._ROWDRV_1.NWL ROWCLK5 VDDCE VNWC P11LL_CKT
+  W=0.77U L=0.04U
X_M_wd62._rowdrv_1.MXP13 _WD62._ROWDRV_1.NWL _WD62.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_M_wd7.I69.MX_npd _WD7.ROWSEL DFTRAM_RET VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd7.I69.MX_nr_header VDDP DFTRAM_RET VDDPE VNWP P11LL_CKT W=0.855U L=0.04U
X_M_wd7.I69._nr.MXNA1 _WD7.ROWSEL NXP0_1 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd7.I69._nr.MXNA2 _WD7.ROWSEL NXP1_0 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd7.I69._nr.MXPA1 _WD7.ROWSEL NXP0_1 _WD7.I69._NR.P1 VNWP P11LL_CKT
+  W=0.855U L=0.04U
X_M_wd7.I69._nr.MXPA2 _WD7.I69._NR.P1 NXP1_0 VDDP VNWP P11LL_CKT W=0.855U
+  L=0.04U
X_M_wd7._rowdrv_0.MXN10 NI6 ROWCLK6 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_M_wd7._rowdrv_0.MXN11 WL14 _WD7._ROWDRV_0.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_M_wd7._rowdrv_0.MXN8 _WD7._ROWDRV_0.NWL _WD7.ROWSEL NI6 VPW N11LL_CKT
+  W=1.02U L=0.04U
X_M_wd7._rowdrv_0.MXP1 WL14 _WD7._ROWDRV_0.NWL VDDC_L VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_M_wd7._rowdrv_0.MXP12 _WD7._ROWDRV_0.NWL ROWCLK6 VDDCE VNWC P11LL_CKT
+  W=0.77U L=0.04U
X_M_wd7._rowdrv_0.MXP13 _WD7._ROWDRV_0.NWL _WD7.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_M_wd7._rowdrv_1.MXN10 NI7 ROWCLK7 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_M_wd7._rowdrv_1.MXN11 WL15 _WD7._ROWDRV_1.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_M_wd7._rowdrv_1.MXN8 _WD7._ROWDRV_1.NWL _WD7.ROWSEL NI7 VPW N11LL_CKT
+  W=1.02U L=0.04U
X_M_wd7._rowdrv_1.MXP1 WL15 _WD7._ROWDRV_1.NWL VDDC_R VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_M_wd7._rowdrv_1.MXP12 _WD7._ROWDRV_1.NWL ROWCLK7 VDDCE VNWC P11LL_CKT
+  W=0.77U L=0.04U
X_M_wd7._rowdrv_1.MXP13 _WD7._ROWDRV_1.NWL _WD7.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_M_wd8.I69.MX_npd _WD8.ROWSEL DFTRAM_RET VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd8.I69.MX_nr_header VDDP DFTRAM_RET VDDPE VNWP P11LL_CKT W=0.855U L=0.04U
X_M_wd8.I69._nr.MXNA1 _WD8.ROWSEL NXP0_2 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd8.I69._nr.MXNA2 _WD8.ROWSEL NXP1_0 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd8.I69._nr.MXPA1 _WD8.ROWSEL NXP0_2 _WD8.I69._NR.P1 VNWP P11LL_CKT
+  W=0.855U L=0.04U
X_M_wd8.I69._nr.MXPA2 _WD8.I69._NR.P1 NXP1_0 VDDP VNWP P11LL_CKT W=0.855U
+  L=0.04U
X_M_wd8._rowdrv_0.MXN10 NI0 ROWCLK0 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_M_wd8._rowdrv_0.MXN11 WL16 _WD8._ROWDRV_0.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_M_wd8._rowdrv_0.MXN8 _WD8._ROWDRV_0.NWL _WD8.ROWSEL NI0 VPW N11LL_CKT
+  W=1.02U L=0.04U
X_M_wd8._rowdrv_0.MXP1 WL16 _WD8._ROWDRV_0.NWL VDDC_L VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_M_wd8._rowdrv_0.MXP12 _WD8._ROWDRV_0.NWL ROWCLK0 VDDCE VNWC P11LL_CKT
+  W=0.77U L=0.04U
X_M_wd8._rowdrv_0.MXP13 _WD8._ROWDRV_0.NWL _WD8.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_M_wd8._rowdrv_1.MXN10 NI1 ROWCLK1 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_M_wd8._rowdrv_1.MXN11 WL17 _WD8._ROWDRV_1.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_M_wd8._rowdrv_1.MXN8 _WD8._ROWDRV_1.NWL _WD8.ROWSEL NI1 VPW N11LL_CKT
+  W=1.02U L=0.04U
X_M_wd8._rowdrv_1.MXP1 WL17 _WD8._ROWDRV_1.NWL VDDC_R VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_M_wd8._rowdrv_1.MXP12 _WD8._ROWDRV_1.NWL ROWCLK1 VDDCE VNWC P11LL_CKT
+  W=0.77U L=0.04U
X_M_wd8._rowdrv_1.MXP13 _WD8._ROWDRV_1.NWL _WD8.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_M_wd9.I69.MX_npd _WD9.ROWSEL DFTRAM_RET VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd9.I69.MX_nr_header VDDP DFTRAM_RET VDDPE VNWP P11LL_CKT W=0.855U L=0.04U
X_M_wd9.I69._nr.MXNA1 _WD9.ROWSEL NXP0_2 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd9.I69._nr.MXNA2 _WD9.ROWSEL NXP1_0 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_M_wd9.I69._nr.MXPA1 _WD9.ROWSEL NXP0_2 _WD9.I69._NR.P1 VNWP P11LL_CKT
+  W=0.855U L=0.04U
X_M_wd9.I69._nr.MXPA2 _WD9.I69._NR.P1 NXP1_0 VDDP VNWP P11LL_CKT W=0.855U
+  L=0.04U
X_M_wd9._rowdrv_0.MXN10 NI2 ROWCLK2 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_M_wd9._rowdrv_0.MXN11 WL18 _WD9._ROWDRV_0.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_M_wd9._rowdrv_0.MXN8 _WD9._ROWDRV_0.NWL _WD9.ROWSEL NI2 VPW N11LL_CKT
+  W=1.02U L=0.04U
X_M_wd9._rowdrv_0.MXP1 WL18 _WD9._ROWDRV_0.NWL VDDC_L VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_M_wd9._rowdrv_0.MXP12 _WD9._ROWDRV_0.NWL ROWCLK2 VDDCE VNWC P11LL_CKT
+  W=0.77U L=0.04U
X_M_wd9._rowdrv_0.MXP13 _WD9._ROWDRV_0.NWL _WD9.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_M_wd9._rowdrv_1.MXN10 NI3 ROWCLK3 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_M_wd9._rowdrv_1.MXN11 WL19 _WD9._ROWDRV_1.NWL VSSE VPW N11LL_CKT W=3.4U
+  L=0.04U
X_M_wd9._rowdrv_1.MXN8 _WD9._ROWDRV_1.NWL _WD9.ROWSEL NI3 VPW N11LL_CKT
+  W=1.02U L=0.04U
X_M_wd9._rowdrv_1.MXP1 WL19 _WD9._ROWDRV_1.NWL VDDC_R VNWC P11LL_CKT W=8.52U
+  L=0.04U
X_M_wd9._rowdrv_1.MXP12 _WD9._ROWDRV_1.NWL ROWCLK3 VDDCE VNWC P11LL_CKT
+  W=0.77U L=0.04U
X_M_wd9._rowdrv_1.MXP13 _WD9._ROWDRV_1.NWL _WD9.ROWSEL VDDCE VNWC P11LL_CKT
+  W=0.455U L=0.04U
X_M_wdxtop.I69.MX_npd _WDXTOP.ROWSEL DFTRAM_RET VSSE VPW N11LL_CKT W=0.28U
+  L=0.04U
X_M_wdxtop.I69.MX_nr_header VDDP DFTRAM_RET VDDPE VNWP P11LL_CKT W=0.855U
+  L=0.04U
X_M_wdxtop.I69._nr.MXNA1 _WDXTOP.ROWSEL NXP0_7 VSSE VPW N11LL_CKT W=0.28U
+  L=0.04U
X_M_wdxtop.I69._nr.MXNA2 _WDXTOP.ROWSEL NXP1_0 VSSE VPW N11LL_CKT W=0.28U
+  L=0.04U
X_M_wdxtop.I69._nr.MXPA1 _WDXTOP.ROWSEL NXP0_7 _WDXTOP.I69._NR.P1 VNWP
+  P11LL_CKT W=0.855U L=0.04U
X_M_wdxtop.I69._nr.MXPA2 _WDXTOP.I69._NR.P1 NXP1_0 VDDP VNWP P11LL_CKT
+  W=0.855U L=0.04U
X_M_wdxtop._rowdrv_0.MXN10 NI6 ROWCLK6 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_M_wdxtop._rowdrv_0.MXN11 WL62 _WDXTOP._ROWDRV_0.NWL VSSE VPW N11LL_CKT
+  W=3.4U L=0.04U
X_M_wdxtop._rowdrv_0.MXN8 _WDXTOP._ROWDRV_0.NWL _WDXTOP.ROWSEL NI6 VPW
+  N11LL_CKT W=1.02U L=0.04U
X_M_wdxtop._rowdrv_0.MXP1 WL62 _WDXTOP._ROWDRV_0.NWL VDDC_L VNWC P11LL_CKT
+  W=8.52U L=0.04U
X_M_wdxtop._rowdrv_0.MXP12 _WDXTOP._ROWDRV_0.NWL ROWCLK6 VDDCE VNWC P11LL_CKT
+  W=0.77U L=0.04U
X_M_wdxtop._rowdrv_0.MXP13 _WDXTOP._ROWDRV_0.NWL _WDXTOP.ROWSEL VDDCE VNWC
+  P11LL_CKT W=0.455U L=0.04U
X_M_wdxtop._rowdrv_1.MXN10 NI7 ROWCLK7 VSSE VPW N11LL_CKT W=0.34U L=0.04U
X_M_wdxtop._rowdrv_1.MXN11 WL63 _WDXTOP._ROWDRV_1.NWL VSSE VPW N11LL_CKT
+  W=3.4U L=0.04U
X_M_wdxtop._rowdrv_1.MXN8 _WDXTOP._ROWDRV_1.NWL _WDXTOP.ROWSEL NI7 VPW
+  N11LL_CKT W=1.02U L=0.04U
X_M_wdxtop._rowdrv_1.MXP1 WL63 _WDXTOP._ROWDRV_1.NWL VDDC_R VNWC P11LL_CKT
+  W=8.52U L=0.04U
X_M_wdxtop._rowdrv_1.MXP12 _WDXTOP._ROWDRV_1.NWL ROWCLK7 VDDCE VNWC P11LL_CKT
+  W=0.77U L=0.04U
X_M_wdxtop._rowdrv_1.MXP13 _WDXTOP._ROWDRV_1.NWL _WDXTOP.ROWSEL VDDCE VNWC
+  P11LL_CKT W=0.455U L=0.04U
X_M_xdec0._dec.I1_0.MXNA1 _XDEC0._DEC.NDEC[0] NA[0] _XDEC0._DEC.I1_0.N2 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xdec0._dec.I1_0.MXNA2 _XDEC0._DEC.I1_0.N2 NA[1] _XDEC0._DEC.I1_0.N1 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xdec0._dec.I1_0.MXNA3 _XDEC0._DEC.I1_0.N1 NA[2] VSS VPW N11LL_CKT W=0.51U
+  L=0.04U
X_M_xdec0._dec.I1_0.MXPA1 _XDEC0._DEC.NDEC[0] NA[0] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xdec0._dec.I1_0.MXPA2 _XDEC0._DEC.NDEC[0] NA[1] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xdec0._dec.I1_0.MXPA3 _XDEC0._DEC.NDEC[0] NA[2] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xdec0._dec.I1_1.MXNA1 _XDEC0._DEC.NDEC[1] IA[0] _XDEC0._DEC.I1_1.N2 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xdec0._dec.I1_1.MXNA2 _XDEC0._DEC.I1_1.N2 NA[1] _XDEC0._DEC.I1_1.N1 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xdec0._dec.I1_1.MXNA3 _XDEC0._DEC.I1_1.N1 NA[2] VSS VPW N11LL_CKT W=0.51U
+  L=0.04U
X_M_xdec0._dec.I1_1.MXPA1 _XDEC0._DEC.NDEC[1] IA[0] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xdec0._dec.I1_1.MXPA2 _XDEC0._DEC.NDEC[1] NA[1] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xdec0._dec.I1_1.MXPA3 _XDEC0._DEC.NDEC[1] NA[2] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xdec0._dec.I1_2.MXNA1 _XDEC0._DEC.NDEC[2] NA[0] _XDEC0._DEC.I1_2.N2 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xdec0._dec.I1_2.MXNA2 _XDEC0._DEC.I1_2.N2 IA[1] _XDEC0._DEC.I1_2.N1 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xdec0._dec.I1_2.MXNA3 _XDEC0._DEC.I1_2.N1 NA[2] VSS VPW N11LL_CKT W=0.51U
+  L=0.04U
X_M_xdec0._dec.I1_2.MXPA1 _XDEC0._DEC.NDEC[2] NA[0] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xdec0._dec.I1_2.MXPA2 _XDEC0._DEC.NDEC[2] IA[1] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xdec0._dec.I1_2.MXPA3 _XDEC0._DEC.NDEC[2] NA[2] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xdec0._dec.I1_3.MXNA1 _XDEC0._DEC.NDEC[3] IA[0] _XDEC0._DEC.I1_3.N2 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xdec0._dec.I1_3.MXNA2 _XDEC0._DEC.I1_3.N2 IA[1] _XDEC0._DEC.I1_3.N1 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xdec0._dec.I1_3.MXNA3 _XDEC0._DEC.I1_3.N1 NA[2] VSS VPW N11LL_CKT W=0.51U
+  L=0.04U
X_M_xdec0._dec.I1_3.MXPA1 _XDEC0._DEC.NDEC[3] IA[0] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xdec0._dec.I1_3.MXPA2 _XDEC0._DEC.NDEC[3] IA[1] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xdec0._dec.I1_3.MXPA3 _XDEC0._DEC.NDEC[3] NA[2] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xdec0._dec.I1_4.MXNA1 _XDEC0._DEC.NDEC[4] NA[0] _XDEC0._DEC.I1_4.N2 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xdec0._dec.I1_4.MXNA2 _XDEC0._DEC.I1_4.N2 NA[1] _XDEC0._DEC.I1_4.N1 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xdec0._dec.I1_4.MXNA3 _XDEC0._DEC.I1_4.N1 IA[2] VSS VPW N11LL_CKT W=0.51U
+  L=0.04U
X_M_xdec0._dec.I1_4.MXPA1 _XDEC0._DEC.NDEC[4] NA[0] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xdec0._dec.I1_4.MXPA2 _XDEC0._DEC.NDEC[4] NA[1] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xdec0._dec.I1_4.MXPA3 _XDEC0._DEC.NDEC[4] IA[2] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xdec0._dec.I1_5.MXNA1 _XDEC0._DEC.NDEC[5] IA[0] _XDEC0._DEC.I1_5.N2 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xdec0._dec.I1_5.MXNA2 _XDEC0._DEC.I1_5.N2 NA[1] _XDEC0._DEC.I1_5.N1 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xdec0._dec.I1_5.MXNA3 _XDEC0._DEC.I1_5.N1 IA[2] VSS VPW N11LL_CKT W=0.51U
+  L=0.04U
X_M_xdec0._dec.I1_5.MXPA1 _XDEC0._DEC.NDEC[5] IA[0] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xdec0._dec.I1_5.MXPA2 _XDEC0._DEC.NDEC[5] NA[1] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xdec0._dec.I1_5.MXPA3 _XDEC0._DEC.NDEC[5] IA[2] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xdec0._dec.I1_6.MXNA1 _XDEC0._DEC.NDEC[6] NA[0] _XDEC0._DEC.I1_6.N2 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xdec0._dec.I1_6.MXNA2 _XDEC0._DEC.I1_6.N2 IA[1] _XDEC0._DEC.I1_6.N1 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xdec0._dec.I1_6.MXNA3 _XDEC0._DEC.I1_6.N1 IA[2] VSS VPW N11LL_CKT W=0.51U
+  L=0.04U
X_M_xdec0._dec.I1_6.MXPA1 _XDEC0._DEC.NDEC[6] NA[0] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xdec0._dec.I1_6.MXPA2 _XDEC0._DEC.NDEC[6] IA[1] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xdec0._dec.I1_6.MXPA3 _XDEC0._DEC.NDEC[6] IA[2] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xdec0._dec.I1_7.MXNA1 _XDEC0._DEC.NDEC[7] IA[0] _XDEC0._DEC.I1_7.N2 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xdec0._dec.I1_7.MXNA2 _XDEC0._DEC.I1_7.N2 IA[1] _XDEC0._DEC.I1_7.N1 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xdec0._dec.I1_7.MXNA3 _XDEC0._DEC.I1_7.N1 IA[2] VSS VPW N11LL_CKT W=0.51U
+  L=0.04U
X_M_xdec0._dec.I1_7.MXPA1 _XDEC0._DEC.NDEC[7] IA[0] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xdec0._dec.I1_7.MXPA2 _XDEC0._DEC.NDEC[7] IA[1] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xdec0._dec.I1_7.MXPA3 _XDEC0._DEC.NDEC[7] IA[2] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xdec0._dec.I3_0.MXNA1 _XDEC0.XP[0] _XDEC0._DEC.NDEC[0] VSS VPW N11LL_CKT
+  W=0.57U L=0.04U
X_M_xdec0._dec.I3_0.MXPA1 _XDEC0.XP[0] _XDEC0._DEC.NDEC[0] VDDPE VNWP
+  P11LL_CKT W=1.02U L=0.04U
X_M_xdec0._dec.I3_1.MXNA1 _XDEC0.XP[1] _XDEC0._DEC.NDEC[1] VSS VPW N11LL_CKT
+  W=0.57U L=0.04U
X_M_xdec0._dec.I3_1.MXPA1 _XDEC0.XP[1] _XDEC0._DEC.NDEC[1] VDDPE VNWP
+  P11LL_CKT W=1.02U L=0.04U
X_M_xdec0._dec.I3_2.MXNA1 _XDEC0.XP[2] _XDEC0._DEC.NDEC[2] VSS VPW N11LL_CKT
+  W=0.57U L=0.04U
X_M_xdec0._dec.I3_2.MXPA1 _XDEC0.XP[2] _XDEC0._DEC.NDEC[2] VDDPE VNWP
+  P11LL_CKT W=1.02U L=0.04U
X_M_xdec0._dec.I3_3.MXNA1 _XDEC0.XP[3] _XDEC0._DEC.NDEC[3] VSS VPW N11LL_CKT
+  W=0.57U L=0.04U
X_M_xdec0._dec.I3_3.MXPA1 _XDEC0.XP[3] _XDEC0._DEC.NDEC[3] VDDPE VNWP
+  P11LL_CKT W=1.02U L=0.04U
X_M_xdec0._dec.I3_4.MXNA1 _XDEC0.XP[4] _XDEC0._DEC.NDEC[4] VSS VPW N11LL_CKT
+  W=0.57U L=0.04U
X_M_xdec0._dec.I3_4.MXPA1 _XDEC0.XP[4] _XDEC0._DEC.NDEC[4] VDDPE VNWP
+  P11LL_CKT W=1.02U L=0.04U
X_M_xdec0._dec.I3_5.MXNA1 _XDEC0.XP[5] _XDEC0._DEC.NDEC[5] VSS VPW N11LL_CKT
+  W=0.57U L=0.04U
X_M_xdec0._dec.I3_5.MXPA1 _XDEC0.XP[5] _XDEC0._DEC.NDEC[5] VDDPE VNWP
+  P11LL_CKT W=1.02U L=0.04U
X_M_xdec0._dec.I3_6.MXNA1 _XDEC0.XP[6] _XDEC0._DEC.NDEC[6] VSS VPW N11LL_CKT
+  W=0.57U L=0.04U
X_M_xdec0._dec.I3_6.MXPA1 _XDEC0.XP[6] _XDEC0._DEC.NDEC[6] VDDPE VNWP
+  P11LL_CKT W=1.02U L=0.04U
X_M_xdec0._dec.I3_7.MXNA1 _XDEC0.XP[7] _XDEC0._DEC.NDEC[7] VSS VPW N11LL_CKT
+  W=0.57U L=0.04U
X_M_xdec0._dec.I3_7.MXPA1 _XDEC0.XP[7] _XDEC0._DEC.NDEC[7] VDDPE VNWP
+  P11LL_CKT W=1.02U L=0.04U
X_M_xdec0._iv_nxp_0.MXNA1 NXP0_0 _XDEC0.XP[0] VSS VPW N11LL_CKT W=2.38U
+  L=0.04U
X_M_xdec0._iv_nxp_0.MXPA1 NXP0_0 _XDEC0.XP[0] VDDPE VNWP P11LL_CKT W=3.7U
+  L=0.04U
X_M_xdec0._iv_nxp_1.MXNA1 NXP0_1 _XDEC0.XP[1] VSS VPW N11LL_CKT W=2.38U
+  L=0.04U
X_M_xdec0._iv_nxp_1.MXPA1 NXP0_1 _XDEC0.XP[1] VDDPE VNWP P11LL_CKT W=3.7U
+  L=0.04U
X_M_xdec0._iv_nxp_2.MXNA1 NXP0_2 _XDEC0.XP[2] VSS VPW N11LL_CKT W=2.38U
+  L=0.04U
X_M_xdec0._iv_nxp_2.MXPA1 NXP0_2 _XDEC0.XP[2] VDDPE VNWP P11LL_CKT W=3.7U
+  L=0.04U
X_M_xdec0._iv_nxp_3.MXNA1 NXP0_3 _XDEC0.XP[3] VSS VPW N11LL_CKT W=2.38U
+  L=0.04U
X_M_xdec0._iv_nxp_3.MXPA1 NXP0_3 _XDEC0.XP[3] VDDPE VNWP P11LL_CKT W=3.7U
+  L=0.04U
X_M_xdec0._iv_nxp_4.MXNA1 NXP0_4 _XDEC0.XP[4] VSS VPW N11LL_CKT W=2.38U
+  L=0.04U
X_M_xdec0._iv_nxp_4.MXPA1 NXP0_4 _XDEC0.XP[4] VDDPE VNWP P11LL_CKT W=3.7U
+  L=0.04U
X_M_xdec0._iv_nxp_5.MXNA1 NXP0_5 _XDEC0.XP[5] VSS VPW N11LL_CKT W=2.38U
+  L=0.04U
X_M_xdec0._iv_nxp_5.MXPA1 NXP0_5 _XDEC0.XP[5] VDDPE VNWP P11LL_CKT W=3.7U
+  L=0.04U
X_M_xdec0._iv_nxp_6.MXNA1 NXP0_6 _XDEC0.XP[6] VSS VPW N11LL_CKT W=2.38U
+  L=0.04U
X_M_xdec0._iv_nxp_6.MXPA1 NXP0_6 _XDEC0.XP[6] VDDPE VNWP P11LL_CKT W=3.7U
+  L=0.04U
X_M_xdec0._iv_nxp_7.MXNA1 NXP0_7 _XDEC0.XP[7] VSS VPW N11LL_CKT W=2.38U
+  L=0.04U
X_M_xdec0._iv_nxp_7.MXPA1 NXP0_7 _XDEC0.XP[7] VDDPE VNWP P11LL_CKT W=3.7U
+  L=0.04U
X_M_xdec1._dec.I1_0.MXNA1 _XDEC1._DEC.NDEC[0] NA[3] _XDEC1._DEC.I1_0.N2 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xdec1._dec.I1_0.MXNA2 _XDEC1._DEC.I1_0.N2 NA[4] _XDEC1._DEC.I1_0.N1 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xdec1._dec.I1_0.MXNA3 _XDEC1._DEC.I1_0.N1 NA[5] VSS VPW N11LL_CKT W=0.51U
+  L=0.04U
X_M_xdec1._dec.I1_0.MXPA1 _XDEC1._DEC.NDEC[0] NA[3] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xdec1._dec.I1_0.MXPA2 _XDEC1._DEC.NDEC[0] NA[4] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xdec1._dec.I1_0.MXPA3 _XDEC1._DEC.NDEC[0] NA[5] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xdec1._dec.I1_1.MXNA1 _XDEC1._DEC.NDEC[1] IA[3] _XDEC1._DEC.I1_1.N2 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xdec1._dec.I1_1.MXNA2 _XDEC1._DEC.I1_1.N2 NA[4] _XDEC1._DEC.I1_1.N1 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xdec1._dec.I1_1.MXNA3 _XDEC1._DEC.I1_1.N1 NA[5] VSS VPW N11LL_CKT W=0.51U
+  L=0.04U
X_M_xdec1._dec.I1_1.MXPA1 _XDEC1._DEC.NDEC[1] IA[3] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xdec1._dec.I1_1.MXPA2 _XDEC1._DEC.NDEC[1] NA[4] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xdec1._dec.I1_1.MXPA3 _XDEC1._DEC.NDEC[1] NA[5] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xdec1._dec.I1_2.MXNA1 _XDEC1._DEC.NDEC[2] NA[3] _XDEC1._DEC.I1_2.N2 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xdec1._dec.I1_2.MXNA2 _XDEC1._DEC.I1_2.N2 IA[4] _XDEC1._DEC.I1_2.N1 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xdec1._dec.I1_2.MXNA3 _XDEC1._DEC.I1_2.N1 NA[5] VSS VPW N11LL_CKT W=0.51U
+  L=0.04U
X_M_xdec1._dec.I1_2.MXPA1 _XDEC1._DEC.NDEC[2] NA[3] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xdec1._dec.I1_2.MXPA2 _XDEC1._DEC.NDEC[2] IA[4] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xdec1._dec.I1_2.MXPA3 _XDEC1._DEC.NDEC[2] NA[5] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xdec1._dec.I1_3.MXNA1 _XDEC1._DEC.NDEC[3] IA[3] _XDEC1._DEC.I1_3.N2 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xdec1._dec.I1_3.MXNA2 _XDEC1._DEC.I1_3.N2 IA[4] _XDEC1._DEC.I1_3.N1 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xdec1._dec.I1_3.MXNA3 _XDEC1._DEC.I1_3.N1 NA[5] VSS VPW N11LL_CKT W=0.51U
+  L=0.04U
X_M_xdec1._dec.I1_3.MXPA1 _XDEC1._DEC.NDEC[3] IA[3] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xdec1._dec.I1_3.MXPA2 _XDEC1._DEC.NDEC[3] IA[4] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xdec1._dec.I1_3.MXPA3 _XDEC1._DEC.NDEC[3] NA[5] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xdec1._dec.I1_4.MXNA1 _XDEC1._DEC.NDEC[4] NA[3] _XDEC1._DEC.I1_4.N2 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xdec1._dec.I1_4.MXNA2 _XDEC1._DEC.I1_4.N2 NA[4] _XDEC1._DEC.I1_4.N1 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xdec1._dec.I1_4.MXNA3 _XDEC1._DEC.I1_4.N1 IA[5] VSS VPW N11LL_CKT W=0.51U
+  L=0.04U
X_M_xdec1._dec.I1_4.MXPA1 _XDEC1._DEC.NDEC[4] NA[3] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xdec1._dec.I1_4.MXPA2 _XDEC1._DEC.NDEC[4] NA[4] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xdec1._dec.I1_4.MXPA3 _XDEC1._DEC.NDEC[4] IA[5] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xdec1._dec.I1_5.MXNA1 _XDEC1._DEC.NDEC[5] IA[3] _XDEC1._DEC.I1_5.N2 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xdec1._dec.I1_5.MXNA2 _XDEC1._DEC.I1_5.N2 NA[4] _XDEC1._DEC.I1_5.N1 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xdec1._dec.I1_5.MXNA3 _XDEC1._DEC.I1_5.N1 IA[5] VSS VPW N11LL_CKT W=0.51U
+  L=0.04U
X_M_xdec1._dec.I1_5.MXPA1 _XDEC1._DEC.NDEC[5] IA[3] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xdec1._dec.I1_5.MXPA2 _XDEC1._DEC.NDEC[5] NA[4] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xdec1._dec.I1_5.MXPA3 _XDEC1._DEC.NDEC[5] IA[5] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xdec1._dec.I1_6.MXNA1 _XDEC1._DEC.NDEC[6] NA[3] _XDEC1._DEC.I1_6.N2 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xdec1._dec.I1_6.MXNA2 _XDEC1._DEC.I1_6.N2 IA[4] _XDEC1._DEC.I1_6.N1 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xdec1._dec.I1_6.MXNA3 _XDEC1._DEC.I1_6.N1 IA[5] VSS VPW N11LL_CKT W=0.51U
+  L=0.04U
X_M_xdec1._dec.I1_6.MXPA1 _XDEC1._DEC.NDEC[6] NA[3] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xdec1._dec.I1_6.MXPA2 _XDEC1._DEC.NDEC[6] IA[4] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xdec1._dec.I1_6.MXPA3 _XDEC1._DEC.NDEC[6] IA[5] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xdec1._dec.I1_7.MXNA1 _XDEC1._DEC.NDEC[7] IA[3] _XDEC1._DEC.I1_7.N2 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xdec1._dec.I1_7.MXNA2 _XDEC1._DEC.I1_7.N2 IA[4] _XDEC1._DEC.I1_7.N1 VPW
+  N11LL_CKT W=0.51U L=0.04U
X_M_xdec1._dec.I1_7.MXNA3 _XDEC1._DEC.I1_7.N1 IA[5] VSS VPW N11LL_CKT W=0.51U
+  L=0.04U
X_M_xdec1._dec.I1_7.MXPA1 _XDEC1._DEC.NDEC[7] IA[3] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xdec1._dec.I1_7.MXPA2 _XDEC1._DEC.NDEC[7] IA[4] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xdec1._dec.I1_7.MXPA3 _XDEC1._DEC.NDEC[7] IA[5] VDDPE VNWP P11LL_CKT
+  W=0.4U L=0.04U
X_M_xdec1._dec.I3_0.MXNA1 _XDEC1.XP[0] _XDEC1._DEC.NDEC[0] VSS VPW N11LL_CKT
+  W=0.57U L=0.04U
X_M_xdec1._dec.I3_0.MXPA1 _XDEC1.XP[0] _XDEC1._DEC.NDEC[0] VDDPE VNWP
+  P11LL_CKT W=1.02U L=0.04U
X_M_xdec1._dec.I3_1.MXNA1 _XDEC1.XP[1] _XDEC1._DEC.NDEC[1] VSS VPW N11LL_CKT
+  W=0.57U L=0.04U
X_M_xdec1._dec.I3_1.MXPA1 _XDEC1.XP[1] _XDEC1._DEC.NDEC[1] VDDPE VNWP
+  P11LL_CKT W=1.02U L=0.04U
X_M_xdec1._dec.I3_2.MXNA1 _XDEC1.XP[2] _XDEC1._DEC.NDEC[2] VSS VPW N11LL_CKT
+  W=0.57U L=0.04U
X_M_xdec1._dec.I3_2.MXPA1 _XDEC1.XP[2] _XDEC1._DEC.NDEC[2] VDDPE VNWP
+  P11LL_CKT W=1.02U L=0.04U
X_M_xdec1._dec.I3_3.MXNA1 _XDEC1.XP[3] _XDEC1._DEC.NDEC[3] VSS VPW N11LL_CKT
+  W=0.57U L=0.04U
X_M_xdec1._dec.I3_3.MXPA1 _XDEC1.XP[3] _XDEC1._DEC.NDEC[3] VDDPE VNWP
+  P11LL_CKT W=1.02U L=0.04U
X_M_xdec1._dec.I3_4.MXNA1 _XDEC1.XP[4] _XDEC1._DEC.NDEC[4] VSS VPW N11LL_CKT
+  W=0.57U L=0.04U
X_M_xdec1._dec.I3_4.MXPA1 _XDEC1.XP[4] _XDEC1._DEC.NDEC[4] VDDPE VNWP
+  P11LL_CKT W=1.02U L=0.04U
X_M_xdec1._dec.I3_5.MXNA1 _XDEC1.XP[5] _XDEC1._DEC.NDEC[5] VSS VPW N11LL_CKT
+  W=0.57U L=0.04U
X_M_xdec1._dec.I3_5.MXPA1 _XDEC1.XP[5] _XDEC1._DEC.NDEC[5] VDDPE VNWP
+  P11LL_CKT W=1.02U L=0.04U
X_M_xdec1._dec.I3_6.MXNA1 _XDEC1.XP[6] _XDEC1._DEC.NDEC[6] VSS VPW N11LL_CKT
+  W=0.57U L=0.04U
X_M_xdec1._dec.I3_6.MXPA1 _XDEC1.XP[6] _XDEC1._DEC.NDEC[6] VDDPE VNWP
+  P11LL_CKT W=1.02U L=0.04U
X_M_xdec1._dec.I3_7.MXNA1 _XDEC1.XP[7] _XDEC1._DEC.NDEC[7] VSS VPW N11LL_CKT
+  W=0.57U L=0.04U
X_M_xdec1._dec.I3_7.MXPA1 _XDEC1.XP[7] _XDEC1._DEC.NDEC[7] VDDPE VNWP
+  P11LL_CKT W=1.02U L=0.04U
X_M_xdec1._iv_nxp_0.MXNA1 NXP1_0 _XDEC1.XP[0] VSS VPW N11LL_CKT W=2.38U
+  L=0.04U
X_M_xdec1._iv_nxp_0.MXPA1 NXP1_0 _XDEC1.XP[0] VDDPE VNWP P11LL_CKT W=3.7U
+  L=0.04U
X_M_xdec1._iv_nxp_1.MXNA1 NXP1_1 _XDEC1.XP[1] VSS VPW N11LL_CKT W=2.38U
+  L=0.04U
X_M_xdec1._iv_nxp_1.MXPA1 NXP1_1 _XDEC1.XP[1] VDDPE VNWP P11LL_CKT W=3.7U
+  L=0.04U
X_M_xdec1._iv_nxp_2.MXNA1 NXP1_2 _XDEC1.XP[2] VSS VPW N11LL_CKT W=2.38U
+  L=0.04U
X_M_xdec1._iv_nxp_2.MXPA1 NXP1_2 _XDEC1.XP[2] VDDPE VNWP P11LL_CKT W=3.7U
+  L=0.04U
X_M_xdec1._iv_nxp_3.MXNA1 NXP1_3 _XDEC1.XP[3] VSS VPW N11LL_CKT W=2.38U
+  L=0.04U
X_M_xdec1._iv_nxp_3.MXPA1 NXP1_3 _XDEC1.XP[3] VDDPE VNWP P11LL_CKT W=3.7U
+  L=0.04U
X_M_xdec1._iv_nxp_4.MXNA1 NXP1_4 _XDEC1.XP[4] VSS VPW N11LL_CKT W=2.38U
+  L=0.04U
X_M_xdec1._iv_nxp_4.MXPA1 NXP1_4 _XDEC1.XP[4] VDDPE VNWP P11LL_CKT W=3.7U
+  L=0.04U
X_M_xdec1._iv_nxp_5.MXNA1 NXP1_5 _XDEC1.XP[5] VSS VPW N11LL_CKT W=2.38U
+  L=0.04U
X_M_xdec1._iv_nxp_5.MXPA1 NXP1_5 _XDEC1.XP[5] VDDPE VNWP P11LL_CKT W=3.7U
+  L=0.04U
X_M_xdec1._iv_nxp_6.MXNA1 NXP1_6 _XDEC1.XP[6] VSS VPW N11LL_CKT W=2.38U
+  L=0.04U
X_M_xdec1._iv_nxp_6.MXPA1 NXP1_6 _XDEC1.XP[6] VDDPE VNWP P11LL_CKT W=3.7U
+  L=0.04U
X_M_xdec1._iv_nxp_7.MXNA1 NXP1_7 _XDEC1.XP[7] VSS VPW N11LL_CKT W=2.38U
+  L=0.04U
X_M_xdec1._iv_nxp_7.MXPA1 NXP1_7 _XDEC1.XP[7] VDDPE VNWP P11LL_CKT W=3.7U
+  L=0.04U
.ENDS sram464x144WDX64
****
.SUBCKT sram464x144WDDRVCOL A[0] A[1] A[2] A[3] A[4] A[5] BPGEN BRET1N BRET2N
+  DBL DWL EMA0 EMA1 EMA2 GTPCLK0 GTPCLK1 LA_P2[0] LA_P2[1] LA_P2[2] LOG0
+  LOG0_DWL LOG1 NACT_CC NGWE RET_0 RET_1 SAE_DUMMY VDDC_LEFT VDDC_RIGHT VDDP
+  VDDPE VNWC VNWP VSSE WL0_0 WL0_1 WL0_2 WL0_3 WL0_4 WL0_5 WL0_6 WL0_7 WL0_8
+  WL0_9 WL0_10 WL0_11 WL0_12 WL0_13 WL0_14 WL0_15 WL0_16 WL0_17 WL0_18 WL0_19
+  WL0_20 WL0_21 WL0_22 WL0_23 WL0_24 WL0_25 WL0_26 WL0_27 WL0_28 WL0_29
+  WL0_30 WL0_31 WL0_32 WL0_33 WL0_34 WL0_35 WL0_36 WL0_37 WL0_38 WL0_39
+  WL0_40 WL0_41 WL0_42 WL0_43 WL0_44 WL0_45 WL0_46 WL0_47 WL0_48 WL0_49
+  WL0_50 WL0_51 WL0_52 WL0_53 WL0_54 WL0_55 WL0_56 WL0_57 WL0_58 WL0_59
+  WL0_60 WL0_61 WL0_62 WL0_63 WL0_64 WL0_65 WL0_66 WL0_67 WL0_68 WL0_69
+  WL0_70 WL0_71 WL0_72 WL0_73 WL0_74 WL0_75 WL0_76 WL0_77 WL0_78 WL0_79
+  WL0_80 WL0_81 WL0_82 WL0_83 WL0_84 WL1_0 WL1_1 WL1_2 WL1_3 WL1_4 WL1_5
+  WL1_6 WL1_7 WL1_8 WL1_9 WL1_10 WL1_11 WL1_12 WL1_13 WL1_14 WL1_15 WL1_16
+  WL1_17 WL1_18 WL1_19 WL1_20 WL1_21 WL1_22 WL1_23 WL1_24 WL1_25 WL1_26
+  WL1_27 WL1_28 WL1_29 WL1_30 WL1_31 WL1_32 WL1_33 WL1_34 WL1_35 WL1_36
+  WL1_37 WL1_38 WL1_39 WL1_40 WL1_41 WL1_42 WL1_43 WL1_44 WL1_45 WL1_46
+  WL1_47 WL1_48 WL1_49 WL1_50 WL1_51 WL1_52 WL1_53 WL1_54 WL1_55 WL1_56
+  WL1_57 WL1_58 WL1_59 WL1_60 WL1_61 WL1_62 WL1_63 WL1_64 WL1_65 WL1_66
+  WL1_67 WL1_68 WL1_69 WL1_70 WL1_71 WL1_72 WL1_73 WL1_74 WL1_75 WL1_76
+  WL1_77 WL1_78 WL1_79 WL1_80 WL1_81 WL1_82 WL1_83 WL1_84 WL2 WL3 WL4 WL5 WL6
+  WL7 WL8 WL9 WL10 WL11 WL12 WL13 WL14 WL15 WL16 WL17 WL18 WL19 WL20 WL21
+  WL22 WL23 WL24 WL25 WL26 WL27 WL28 WL29 WL30 WL31 WL32 WL33 WL34 WL35 WL36
+  WL37 WL38 WL39 WL40 WL41 WL42 WL43 WL44 WL45 WL46 WL47 WL48 WL49 WL50 WL51
+  WL52 WL53 WL54 WL55 WL56 WL57 WL58 WL59 WL60 WL61 WL62 WL63
** sram464x144WDDRVCOL: 2763 flat devices **
XWD_BOT BPGEN A[0] A[1] A[2] A[3] A[4] A[5] DBL RET_0 DWL EMA0 EMA1 EMA2
+  GTPCLK0 GTPCLK1 LA_P2[0] LA_P2[1] LA_P2[2] LOG0 LOG0_DWL LOG1 BRET2N
+  NACT_CC NGWE NI0 NI1 NI2 NI3 NI4 NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2
+  NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7 NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4
+  NXP1_5 NXP1_6 NXP1_7 RET_1 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5
+  ROWCLK6 ROWCLK7 SAE_DUMMY VNWC VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE
+  VSSE WL0_0 WL1_0 WL2 WL3 WL4 WL5 WL6 WL7 WL8 WL9 WL10 WL11 WL12 WL13 WL14
+  WL15 WL16 WL17 WL18 WL19 WL20 WL21 WL22 WL23 WL24 WL25 WL26 WL27 WL28 WL29
+  WL30 WL31 WL32 WL33 WL34 WL35 WL36 WL37 WL38 WL39 WL40 WL41 WL42 WL43 WL44
+  WL45 WL46 WL47 WL48 WL49 WL50 WL51 WL52 WL53 WL54 WL55 WL56 WL57 WL58 WL59
+  WL60 WL61 WL62 WL63 sram464x144WDX64
XWD_I0 BPGEN DBL NXP0_0 NXP1_1 NI0 NI1 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4 NI5
+  NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK0 ROWCLK1
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_1 WL1_1 sram464x144WDX2
XWD_I1 BPGEN DBL NXP0_0 NXP1_1 NI2 NI3 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4 NI5
+  NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK2 ROWCLK3
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_2 WL1_2 sram464x144WDX2
XWD_I10 BPGEN DBL NXP0_2 NXP1_1 NI4 NI5 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK4 ROWCLK5
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_11 WL1_11 sram464x144WDX2
XWD_I11 BPGEN DBL NXP0_2 NXP1_1 NI6 NI7 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK6 ROWCLK7
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_12 WL1_12 sram464x144WDX2
XWD_I12 BPGEN DBL NXP0_3 NXP1_1 NI0 NI1 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK0 ROWCLK1
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_13 WL1_13 sram464x144WDX2
XWD_I13 BPGEN DBL NXP0_3 NXP1_1 NI2 NI3 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK2 ROWCLK3
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_14 WL1_14 sram464x144WDX2
XWD_I14 BPGEN DBL NXP0_3 NXP1_1 NI4 NI5 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK4 ROWCLK5
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_15 WL1_15 sram464x144WDX2
XWD_I15 BPGEN DBL NXP0_3 NXP1_1 NI6 NI7 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK6 ROWCLK7
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_16 WL1_16 sram464x144WDX2
XWD_I16 BPGEN DBL NXP0_4 NXP1_1 NI0 NI1 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK0 ROWCLK1
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_17 WL1_17 sram464x144WDX2
XWD_I17 BPGEN DBL NXP0_4 NXP1_1 NI2 NI3 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK2 ROWCLK3
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_18 WL1_18 sram464x144WDX2
XWD_I18 BPGEN DBL NXP0_4 NXP1_1 NI4 NI5 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK4 ROWCLK5
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_19 WL1_19 sram464x144WDX2
XWD_I19 BPGEN DBL NXP0_4 NXP1_1 NI6 NI7 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK6 ROWCLK7
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_20 WL1_20 sram464x144WDX2
XWD_I2 BPGEN DBL NXP0_0 NXP1_1 NI4 NI5 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4 NI5
+  NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK4 ROWCLK5
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_3 WL1_3 sram464x144WDX2
XWD_I20 BPGEN DBL NXP0_5 NXP1_1 NI0 NI1 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK0 ROWCLK1
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_21 WL1_21 sram464x144WDX2
XWD_I21 BPGEN DBL NXP0_5 NXP1_1 NI2 NI3 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK2 ROWCLK3
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_22 WL1_22 sram464x144WDX2
XWD_I22 BPGEN DBL NXP0_5 NXP1_1 NI4 NI5 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK4 ROWCLK5
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_23 WL1_23 sram464x144WDX2
XWD_I23 BPGEN DBL NXP0_5 NXP1_1 NI6 NI7 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK6 ROWCLK7
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_24 WL1_24 sram464x144WDX2
XWD_I24 BPGEN DBL NXP0_6 NXP1_1 NI0 NI1 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK0 ROWCLK1
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_25 WL1_25 sram464x144WDX2
XWD_I25 BPGEN DBL NXP0_6 NXP1_1 NI2 NI3 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK2 ROWCLK3
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_26 WL1_26 sram464x144WDX2
XWD_I26 BPGEN DBL NXP0_6 NXP1_1 NI4 NI5 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK4 ROWCLK5
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_27 WL1_27 sram464x144WDX2
XWD_I27 BPGEN DBL NXP0_6 NXP1_1 NI6 NI7 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK6 ROWCLK7
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_28 WL1_28 sram464x144WDX2
XWD_I28 BPGEN DBL NXP0_7 NXP1_1 NI0 NI1 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK0 ROWCLK1
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_29 WL1_29 sram464x144WDX2
XWD_I29 BPGEN DBL NXP0_7 NXP1_1 NI2 NI3 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK2 ROWCLK3
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_30 WL1_30 sram464x144WDX2
XWD_I3 BPGEN DBL NXP0_0 NXP1_1 NI6 NI7 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4 NI5
+  NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK6 ROWCLK7
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_4 WL1_4 sram464x144WDX2
XWD_I30 BPGEN DBL NXP0_7 NXP1_1 NI4 NI5 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK4 ROWCLK5
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_31 WL1_31 sram464x144WDX2
XWD_I31 BPGEN DBL NXP0_7 NXP1_1 NI6 NI7 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK6 ROWCLK7
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_32 WL1_32 sram464x144WDX2
XWD_I32 BPGEN DBL NXP0_0 NXP1_2 NI0 NI1 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK0 ROWCLK1
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_33 WL1_33 sram464x144WDX2
XWD_I33 BPGEN DBL NXP0_0 NXP1_2 NI2 NI3 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK2 ROWCLK3
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_34 WL1_34 sram464x144WDX2
XWD_I34 BPGEN DBL NXP0_0 NXP1_2 NI4 NI5 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK4 ROWCLK5
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_35 WL1_35 sram464x144WDX2
XWD_I35 BPGEN DBL NXP0_0 NXP1_2 NI6 NI7 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK6 ROWCLK7
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_36 WL1_36 sram464x144WDX2
XWD_I36 BPGEN DBL NXP0_1 NXP1_2 NI0 NI1 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK0 ROWCLK1
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_37 WL1_37 sram464x144WDX2
XWD_I37 BPGEN DBL NXP0_1 NXP1_2 NI2 NI3 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK2 ROWCLK3
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_38 WL1_38 sram464x144WDX2
XWD_I38 BPGEN DBL NXP0_1 NXP1_2 NI4 NI5 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK4 ROWCLK5
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_39 WL1_39 sram464x144WDX2
XWD_I39 BPGEN DBL NXP0_1 NXP1_2 NI6 NI7 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK6 ROWCLK7
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_40 WL1_40 sram464x144WDX2
XWD_I4 BPGEN DBL NXP0_1 NXP1_1 NI0 NI1 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4 NI5
+  NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK0 ROWCLK1
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_5 WL1_5 sram464x144WDX2
XWD_I40 BPGEN DBL NXP0_2 NXP1_2 NI0 NI1 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK0 ROWCLK1
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_41 WL1_41 sram464x144WDX2
XWD_I41 BPGEN DBL NXP0_2 NXP1_2 NI2 NI3 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK2 ROWCLK3
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_42 WL1_42 sram464x144WDX2
XWD_I42 BPGEN DBL NXP0_2 NXP1_2 NI4 NI5 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK4 ROWCLK5
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_43 WL1_43 sram464x144WDX2
XWD_I43 BPGEN DBL NXP0_2 NXP1_2 NI6 NI7 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK6 ROWCLK7
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_44 WL1_44 sram464x144WDX2
XWD_I44 BPGEN DBL NXP0_3 NXP1_2 NI0 NI1 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK0 ROWCLK1
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_45 WL1_45 sram464x144WDX2
XWD_I45 BPGEN DBL NXP0_3 NXP1_2 NI2 NI3 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK2 ROWCLK3
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_46 WL1_46 sram464x144WDX2
XWD_I46 BPGEN DBL NXP0_3 NXP1_2 NI4 NI5 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK4 ROWCLK5
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_47 WL1_47 sram464x144WDX2
XWD_I47 BPGEN DBL NXP0_3 NXP1_2 NI6 NI7 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK6 ROWCLK7
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_48 WL1_48 sram464x144WDX2
XWD_I48 BPGEN DBL NXP0_4 NXP1_2 NI0 NI1 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK0 ROWCLK1
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_49 WL1_49 sram464x144WDX2
XWD_I49 BPGEN DBL NXP0_4 NXP1_2 NI2 NI3 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK2 ROWCLK3
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_50 WL1_50 sram464x144WDX2
XWD_I5 BPGEN DBL NXP0_1 NXP1_1 NI2 NI3 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4 NI5
+  NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK2 ROWCLK3
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_6 WL1_6 sram464x144WDX2
XWD_I50 BPGEN DBL NXP0_4 NXP1_2 NI4 NI5 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK4 ROWCLK5
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_51 WL1_51 sram464x144WDX2
XWD_I51 BPGEN DBL NXP0_4 NXP1_2 NI6 NI7 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK6 ROWCLK7
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_52 WL1_52 sram464x144WDX2
XWD_I52 BPGEN DBL NXP0_5 NXP1_2 NI0 NI1 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK0 ROWCLK1
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_53 WL1_53 sram464x144WDX2
XWD_I53 BPGEN DBL NXP0_5 NXP1_2 NI2 NI3 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK2 ROWCLK3
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_54 WL1_54 sram464x144WDX2
XWD_I54 BPGEN DBL NXP0_5 NXP1_2 NI4 NI5 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK4 ROWCLK5
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_55 WL1_55 sram464x144WDX2
XWD_I55 BPGEN DBL NXP0_5 NXP1_2 NI6 NI7 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK6 ROWCLK7
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_56 WL1_56 sram464x144WDX2
XWD_I56 BPGEN DBL NXP0_6 NXP1_2 NI0 NI1 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK0 ROWCLK1
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_57 WL1_57 sram464x144WDX2
XWD_I57 BPGEN DBL NXP0_6 NXP1_2 NI2 NI3 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK2 ROWCLK3
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_58 WL1_58 sram464x144WDX2
XWD_I58 BPGEN DBL NXP0_6 NXP1_2 NI4 NI5 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK4 ROWCLK5
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_59 WL1_59 sram464x144WDX2
XWD_I59 BPGEN DBL NXP0_6 NXP1_2 NI6 NI7 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK6 ROWCLK7
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_60 WL1_60 sram464x144WDX2
XWD_I6 BPGEN DBL NXP0_1 NXP1_1 NI4 NI5 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4 NI5
+  NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK4 ROWCLK5
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_7 WL1_7 sram464x144WDX2
XWD_I60 BPGEN DBL NXP0_7 NXP1_2 NI0 NI1 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK0 ROWCLK1
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_61 WL1_61 sram464x144WDX2
XWD_I61 BPGEN DBL NXP0_7 NXP1_2 NI2 NI3 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK2 ROWCLK3
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_62 WL1_62 sram464x144WDX2
XWD_I62 BPGEN DBL NXP0_7 NXP1_2 NI4 NI5 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK4 ROWCLK5
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_63 WL1_63 sram464x144WDX2
XWD_I63 BPGEN DBL NXP0_7 NXP1_2 NI6 NI7 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK6 ROWCLK7
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_64 WL1_64 sram464x144WDX2
XWD_I64 BPGEN DBL NXP0_0 NXP1_3 NI0 NI1 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK0 ROWCLK1
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_65 WL1_65 sram464x144WDX2
XWD_I65 BPGEN DBL NXP0_0 NXP1_3 NI2 NI3 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK2 ROWCLK3
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_66 WL1_66 sram464x144WDX2
XWD_I66 BPGEN DBL NXP0_0 NXP1_3 NI4 NI5 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK4 ROWCLK5
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_67 WL1_67 sram464x144WDX2
XWD_I67 BPGEN DBL NXP0_0 NXP1_3 NI6 NI7 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK6 ROWCLK7
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_68 WL1_68 sram464x144WDX2
XWD_I68 BPGEN DBL NXP0_1 NXP1_3 NI0 NI1 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK0 ROWCLK1
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_69 WL1_69 sram464x144WDX2
XWD_I69 BPGEN DBL NXP0_1 NXP1_3 NI2 NI3 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK2 ROWCLK3
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_70 WL1_70 sram464x144WDX2
XWD_I7 BPGEN DBL NXP0_1 NXP1_1 NI6 NI7 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4 NI5
+  NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK6 ROWCLK7
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_8 WL1_8 sram464x144WDX2
XWD_I70 BPGEN DBL NXP0_1 NXP1_3 NI4 NI5 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK4 ROWCLK5
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_71 WL1_71 sram464x144WDX2
XWD_I71 BPGEN DBL NXP0_1 NXP1_3 NI6 NI7 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK6 ROWCLK7
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_72 WL1_72 sram464x144WDX2
XWD_I72 BPGEN DBL NXP0_2 NXP1_3 NI0 NI1 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK0 ROWCLK1
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_73 WL1_73 sram464x144WDX2
XWD_I73 BPGEN DBL NXP0_2 NXP1_3 NI2 NI3 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK2 ROWCLK3
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_74 WL1_74 sram464x144WDX2
XWD_I74 BPGEN DBL NXP0_2 NXP1_3 NI4 NI5 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK4 ROWCLK5
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_75 WL1_75 sram464x144WDX2
XWD_I75 BPGEN DBL NXP0_2 NXP1_3 NI6 NI7 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK6 ROWCLK7
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_76 WL1_76 sram464x144WDX2
XWD_I76 BPGEN DBL NXP0_3 NXP1_3 NI0 NI1 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK0 ROWCLK1
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_77 WL1_77 sram464x144WDX2
XWD_I77 BPGEN DBL NXP0_3 NXP1_3 NI2 NI3 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK2 ROWCLK3
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_78 WL1_78 sram464x144WDX2
XWD_I78 BPGEN DBL NXP0_3 NXP1_3 NI4 NI5 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK4 ROWCLK5
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_79 WL1_79 sram464x144WDX2
XWD_I79 BPGEN DBL NXP0_3 NXP1_3 NI6 NI7 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK6 ROWCLK7
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_80 WL1_80 sram464x144WDX2
XWD_I8 BPGEN DBL NXP0_2 NXP1_1 NI0 NI1 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4 NI5
+  NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK0 ROWCLK1
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_9 WL1_9 sram464x144WDX2
XWD_I80 BPGEN DBL NXP0_4 NXP1_3 NI0 NI1 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK0 ROWCLK1
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_81 WL1_81 sram464x144WDX2
XWD_I81 BPGEN DBL NXP0_4 NXP1_3 NI2 NI3 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK2 ROWCLK3
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_82 WL1_82 sram464x144WDX2
XWD_I82 BPGEN DBL NXP0_4 NXP1_3 NI4 NI5 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK4 ROWCLK5
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_83 WL1_83 sram464x144WDX2
XWD_I9 BPGEN DBL NXP0_2 NXP1_1 NI2 NI3 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4 NI5
+  NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK2 ROWCLK3
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_10 WL1_10 sram464x144WDX2
XWD_TOP BPGEN DBL NXP0_4 NXP1_3 NI6 NI7 LOG0_DWL BRET2N NI0 NI1 NI2 NI3 NI4
+  NI5 NI6 NI7 BRET1N NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7
+  NXP1_0 NXP1_1 NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 ROWCLK6 ROWCLK7
+  RET_0 ROWCLK0 ROWCLK1 ROWCLK2 ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC
+  VNWC VNWC VDDP VDDPE VNWC VNWP VSSE VSSE VSSE WL0_84 WL1_84 sram464x144WDX2
XWL_CAP BPGEN BRET1N BRET2N DBL LOG0_DWL NI0 NI1 NI2 NI3 NI4 NI5 NI6 NI7
+  NXP0_0 NXP0_1 NXP0_2 NXP0_3 NXP0_4 NXP0_5 NXP0_6 NXP0_7 NXP1_0 NXP1_1
+  NXP1_2 NXP1_3 NXP1_4 NXP1_5 NXP1_6 NXP1_7 RET_0 ROWCLK0 ROWCLK1 ROWCLK2
+  ROWCLK3 ROWCLK4 ROWCLK5 ROWCLK6 ROWCLK7 VNWC VDDC_LEFT VDDC_RIGHT VNWC VDDP
+  VDDPE VNWC VNWP VSSE VSSE VSSE sram464x144WDTOP_WDX64
.ENDS sram464x144WDDRVCOL
****
.SUBCKT sram464x144MEM_SLICE A[0] A[1] A[2] A[3] A[4] A[5] BL[0]_0 BL[0]_1
+  BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7 BL[0]_8 BL[0]_9 BL[0]_10
+  BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15 BL[0]_16 BL[0]_17 BL[0]_18
+  BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23 BL[0]_24 BL[0]_25 BL[0]_26
+  BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31 BL[0]_32 BL[0]_33 BL[0]_34
+  BL[0]_35 BL[0]_36 BL[0]_37 BL[0]_38 BL[0]_39 BL[0]_40 BL[0]_41 BL[0]_42
+  BL[0]_43 BL[0]_44 BL[0]_45 BL[0]_46 BL[0]_47 BL[0]_48 BL[0]_49 BL[0]_50
+  BL[0]_51 BL[0]_52 BL[0]_53 BL[0]_54 BL[0]_55 BL[0]_56 BL[0]_57 BL[0]_58
+  BL[0]_59 BL[0]_60 BL[0]_61 BL[0]_62 BL[0]_63 BL[0]_64 BL[0]_65 BL[0]_66
+  BL[0]_67 BL[0]_68 BL[0]_69 BL[0]_70 BL[0]_71 BL[1]_0 BL[1]_1 BL[1]_2
+  BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11
+  BL[1]_12 BL[1]_13 BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19
+  BL[1]_20 BL[1]_21 BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27
+  BL[1]_28 BL[1]_29 BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35
+  BL[1]_36 BL[1]_37 BL[1]_38 BL[1]_39 BL[1]_40 BL[1]_41 BL[1]_42 BL[1]_43
+  BL[1]_44 BL[1]_45 BL[1]_46 BL[1]_47 BL[1]_48 BL[1]_49 BL[1]_50 BL[1]_51
+  BL[1]_52 BL[1]_53 BL[1]_54 BL[1]_55 BL[1]_56 BL[1]_57 BL[1]_58 BL[1]_59
+  BL[1]_60 BL[1]_61 BL[1]_62 BL[1]_63 BL[1]_64 BL[1]_65 BL[1]_66 BL[1]_67
+  BL[1]_68 BL[1]_69 BL[1]_70 BL[1]_71 BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4
+  BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13
+  BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18 BL[2]_19 BL[2]_20 BL[2]_21
+  BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26 BL[2]_27 BL[2]_28 BL[2]_29
+  BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34 BL[2]_35 BL[2]_36 BL[2]_37
+  BL[2]_38 BL[2]_39 BL[2]_40 BL[2]_41 BL[2]_42 BL[2]_43 BL[2]_44 BL[2]_45
+  BL[2]_46 BL[2]_47 BL[2]_48 BL[2]_49 BL[2]_50 BL[2]_51 BL[2]_52 BL[2]_53
+  BL[2]_54 BL[2]_55 BL[2]_56 BL[2]_57 BL[2]_58 BL[2]_59 BL[2]_60 BL[2]_61
+  BL[2]_62 BL[2]_63 BL[2]_64 BL[2]_65 BL[2]_66 BL[2]_67 BL[2]_68 BL[2]_69
+  BL[2]_70 BL[2]_71 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6
+  BL[3]_7 BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14
+  BL[3]_15 BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22
+  BL[3]_23 BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30
+  BL[3]_31 BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 BL[3]_36 BL[3]_37 BL[3]_38
+  BL[3]_39 BL[3]_40 BL[3]_41 BL[3]_42 BL[3]_43 BL[3]_44 BL[3]_45 BL[3]_46
+  BL[3]_47 BL[3]_48 BL[3]_49 BL[3]_50 BL[3]_51 BL[3]_52 BL[3]_53 BL[3]_54
+  BL[3]_55 BL[3]_56 BL[3]_57 BL[3]_58 BL[3]_59 BL[3]_60 BL[3]_61 BL[3]_62
+  BL[3]_63 BL[3]_64 BL[3]_65 BL[3]_66 BL[3]_67 BL[3]_68 BL[3]_69 BL[3]_70
+  BL[3]_71 BPGEN BRET1N BRET2N DBL DWL EMA0 EMA1 EMA2 GTPCLK0 GTPCLK1
+  LA_P2[0] LA_P2[1] LA_P2[2] LOG0 LOG0_DWL LOG1 NACT_CC NBL[0]_0 NBL[0]_1
+  NBL[0]_2 NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9
+  NBL[0]_10 NBL[0]_11 NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16
+  NBL[0]_17 NBL[0]_18 NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23
+  NBL[0]_24 NBL[0]_25 NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30
+  NBL[0]_31 NBL[0]_32 NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[0]_36 NBL[0]_37
+  NBL[0]_38 NBL[0]_39 NBL[0]_40 NBL[0]_41 NBL[0]_42 NBL[0]_43 NBL[0]_44
+  NBL[0]_45 NBL[0]_46 NBL[0]_47 NBL[0]_48 NBL[0]_49 NBL[0]_50 NBL[0]_51
+  NBL[0]_52 NBL[0]_53 NBL[0]_54 NBL[0]_55 NBL[0]_56 NBL[0]_57 NBL[0]_58
+  NBL[0]_59 NBL[0]_60 NBL[0]_61 NBL[0]_62 NBL[0]_63 NBL[0]_64 NBL[0]_65
+  NBL[0]_66 NBL[0]_67 NBL[0]_68 NBL[0]_69 NBL[0]_70 NBL[0]_71 NBL[1]_0
+  NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8
+  NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13 NBL[1]_14 NBL[1]_15
+  NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19 NBL[1]_20 NBL[1]_21 NBL[1]_22
+  NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26 NBL[1]_27 NBL[1]_28 NBL[1]_29
+  NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33 NBL[1]_34 NBL[1]_35 NBL[1]_36
+  NBL[1]_37 NBL[1]_38 NBL[1]_39 NBL[1]_40 NBL[1]_41 NBL[1]_42 NBL[1]_43
+  NBL[1]_44 NBL[1]_45 NBL[1]_46 NBL[1]_47 NBL[1]_48 NBL[1]_49 NBL[1]_50
+  NBL[1]_51 NBL[1]_52 NBL[1]_53 NBL[1]_54 NBL[1]_55 NBL[1]_56 NBL[1]_57
+  NBL[1]_58 NBL[1]_59 NBL[1]_60 NBL[1]_61 NBL[1]_62 NBL[1]_63 NBL[1]_64
+  NBL[1]_65 NBL[1]_66 NBL[1]_67 NBL[1]_68 NBL[1]_69 NBL[1]_70 NBL[1]_71
+  NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7
+  NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13 NBL[2]_14
+  NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20 NBL[2]_21
+  NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27 NBL[2]_28
+  NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34 NBL[2]_35
+  NBL[2]_36 NBL[2]_37 NBL[2]_38 NBL[2]_39 NBL[2]_40 NBL[2]_41 NBL[2]_42
+  NBL[2]_43 NBL[2]_44 NBL[2]_45 NBL[2]_46 NBL[2]_47 NBL[2]_48 NBL[2]_49
+  NBL[2]_50 NBL[2]_51 NBL[2]_52 NBL[2]_53 NBL[2]_54 NBL[2]_55 NBL[2]_56
+  NBL[2]_57 NBL[2]_58 NBL[2]_59 NBL[2]_60 NBL[2]_61 NBL[2]_62 NBL[2]_63
+  NBL[2]_64 NBL[2]_65 NBL[2]_66 NBL[2]_67 NBL[2]_68 NBL[2]_69 NBL[2]_70
+  NBL[2]_71 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 NBL[3]_36 NBL[3]_37 NBL[3]_38 NBL[3]_39 NBL[3]_40 NBL[3]_41
+  NBL[3]_42 NBL[3]_43 NBL[3]_44 NBL[3]_45 NBL[3]_46 NBL[3]_47 NBL[3]_48
+  NBL[3]_49 NBL[3]_50 NBL[3]_51 NBL[3]_52 NBL[3]_53 NBL[3]_54 NBL[3]_55
+  NBL[3]_56 NBL[3]_57 NBL[3]_58 NBL[3]_59 NBL[3]_60 NBL[3]_61 NBL[3]_62
+  NBL[3]_63 NBL[3]_64 NBL[3]_65 NBL[3]_66 NBL[3]_67 NBL[3]_68 NBL[3]_69
+  NBL[3]_70 NBL[3]_71 NGWE RET_0 RET_1 SAE_DUMMY VDDC VDDP VDDPE_0 VDDPE_1
+  VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8 VDDPE_9 VDDPE_10
+  VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16 VDDPE_17 VDDPE_18
+  VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24 VDDPE_25 VDDPE_26
+  VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32 VDDPE_33 VDDPE_34
+  VDDPE_35 VDDPE_36 VDDPE_37 VDDPE_38 VDDPE_39 VDDPE_40 VDDPE_41 VDDPE_42
+  VDDPE_43 VDDPE_44 VDDPE_45 VDDPE_46 VDDPE_47 VDDPE_48 VDDPE_49 VDDPE_50
+  VDDPE_51 VDDPE_52 VDDPE_53 VDDPE_54 VDDPE_55 VDDPE_56 VDDPE_57 VDDPE_58
+  VDDPE_59 VDDPE_60 VDDPE_61 VDDPE_62 VDDPE_63 VDDPE_64 VDDPE_65 VDDPE_66
+  VDDPE_67 VDDPE_68 VDDPE_69 VDDPE_70 VDDPE_71 VDDPE_72 VNWP_0 VNWP_1 VNWP_2
+  VNWP_3 VNWP_4 VPW
** sram464x144MEM_SLICE: 408639 flat devices **
XMEMCORE_L BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7
+  BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15
+  BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23
+  BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31
+  BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4
+  BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13
+  BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21
+  BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29
+  BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[2]_0 BL[2]_1
+  BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10
+  BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18
+  BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26
+  BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34
+  BL[2]_35 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7
+  BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15
+  BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23
+  BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31
+  BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4
+  NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12
+  NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19
+  NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26
+  NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33
+  NBL[1]_34 NBL[1]_35 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5
+  NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13
+  NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20
+  NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27
+  NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34
+  NBL[2]_35 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 VDDC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6
+  VDDPE_7 VDDPE_8 VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14
+  VDDPE_15 VDDPE_16 VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22
+  VDDPE_23 VDDPE_24 VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30
+  VDDPE_31 VDDPE_32 VDDPE_33 VDDPE_34 VDDPE_35 VNWP_0 VNWP_1 VPW WL[0]_0
+  WL[0]_1 WL[0]_2 WL[0]_3 WL[0]_4 WL[0]_5 WL[0]_6 WL[0]_7 WL[0]_8 WL[0]_9
+  WL[0]_10 WL[0]_11 WL[0]_12 WL[0]_13 WL[0]_14 WL[0]_15 WL[0]_16 WL[0]_17
+  WL[0]_18 WL[0]_19 WL[0]_20 WL[0]_21 WL[0]_22 WL[0]_23 WL[0]_24 WL[0]_25
+  WL[0]_26 WL[0]_27 WL[0]_28 WL[0]_29 WL[0]_30 WL[0]_31 WL[0]_32 WL[0]_33
+  WL[0]_34 WL[0]_35 WL[0]_36 WL[0]_37 WL[0]_38 WL[0]_39 WL[0]_40 WL[0]_41
+  WL[0]_42 WL[0]_43 WL[0]_44 WL[0]_45 WL[0]_46 WL[0]_47 WL[0]_48 WL[0]_49
+  WL[0]_50 WL[0]_51 WL[0]_52 WL[0]_53 WL[0]_54 WL[0]_55 WL[0]_56 WL[0]_57
+  WL[0]_58 WL[0]_59 WL[0]_60 WL[0]_61 WL[0]_62 WL[0]_63 WL[0]_64 WL[0]_65
+  WL[0]_66 WL[0]_67 WL[0]_68 WL[0]_69 WL[0]_70 WL[0]_71 WL[0]_72 WL[0]_73
+  WL[0]_74 WL[0]_75 WL[0]_76 WL[0]_77 WL[0]_78 WL[0]_79 WL[0]_80 WL[0]_81
+  WL[0]_82 WL[0]_83 WL[0]_84 WL[0]_85 WL[0]_86 WL[0]_87 WL[0]_88 WL[0]_89
+  WL[0]_90 WL[0]_91 WL[0]_92 WL[0]_93 WL[0]_94 WL[0]_95 WL[0]_96 WL[0]_97
+  WL[0]_98 WL[0]_99 WL[0]_100 WL[0]_101 WL[0]_102 WL[0]_103 WL[0]_104
+  WL[0]_105 WL[0]_106 WL[0]_107 WL[0]_108 WL[0]_109 WL[0]_110 WL[0]_111
+  WL[0]_112 WL[0]_113 WL[0]_114 WL[0]_115 WL[1]_0 WL[1]_1 WL[1]_2 WL[1]_3
+  WL[1]_4 WL[1]_5 WL[1]_6 WL[1]_7 WL[1]_8 WL[1]_9 WL[1]_10 WL[1]_11 WL[1]_12
+  WL[1]_13 WL[1]_14 WL[1]_15 WL[1]_16 WL[1]_17 WL[1]_18 WL[1]_19 WL[1]_20
+  WL[1]_21 WL[1]_22 WL[1]_23 WL[1]_24 WL[1]_25 WL[1]_26 WL[1]_27 WL[1]_28
+  WL[1]_29 WL[1]_30 WL[1]_31 WL[1]_32 WL[1]_33 WL[1]_34 WL[1]_35 WL[1]_36
+  WL[1]_37 WL[1]_38 WL[1]_39 WL[1]_40 WL[1]_41 WL[1]_42 WL[1]_43 WL[1]_44
+  WL[1]_45 WL[1]_46 WL[1]_47 WL[1]_48 WL[1]_49 WL[1]_50 WL[1]_51 WL[1]_52
+  WL[1]_53 WL[1]_54 WL[1]_55 WL[1]_56 WL[1]_57 WL[1]_58 WL[1]_59 WL[1]_60
+  WL[1]_61 WL[1]_62 WL[1]_63 WL[1]_64 WL[1]_65 WL[1]_66 WL[1]_67 WL[1]_68
+  WL[1]_69 WL[1]_70 WL[1]_71 WL[1]_72 WL[1]_73 WL[1]_74 WL[1]_75 WL[1]_76
+  WL[1]_77 WL[1]_78 WL[1]_79 WL[1]_80 WL[1]_81 WL[1]_82 WL[1]_83 WL[1]_84
+  WL[1]_85 WL[1]_86 WL[1]_87 WL[1]_88 WL[1]_89 WL[1]_90 WL[1]_91 WL[1]_92
+  WL[1]_93 WL[1]_94 WL[1]_95 WL[1]_96 WL[1]_97 WL[1]_98 WL[1]_99 WL[1]_100
+  WL[1]_101 WL[1]_102 WL[1]_103 WL[1]_104 WL[1]_105 WL[1]_106 WL[1]_107
+  WL[1]_108 WL[1]_109 WL[1]_110 WL[1]_111 WL[1]_112 WL[1]_113 WL[1]_114
+  WL[1]_115 sram464x144MEMCORE_L
XMEMCORE_R BL[0]_36 BL[0]_37 BL[0]_38 BL[0]_39 BL[0]_40 BL[0]_41 BL[0]_42
+  BL[0]_43 BL[0]_44 BL[0]_45 BL[0]_46 BL[0]_47 BL[0]_48 BL[0]_49 BL[0]_50
+  BL[0]_51 BL[0]_52 BL[0]_53 BL[0]_54 BL[0]_55 BL[0]_56 BL[0]_57 BL[0]_58
+  BL[0]_59 BL[0]_60 BL[0]_61 BL[0]_62 BL[0]_63 BL[0]_64 BL[0]_65 BL[0]_66
+  BL[0]_67 BL[0]_68 BL[0]_69 BL[0]_70 BL[0]_71 BL[1]_36 BL[1]_37 BL[1]_38
+  BL[1]_39 BL[1]_40 BL[1]_41 BL[1]_42 BL[1]_43 BL[1]_44 BL[1]_45 BL[1]_46
+  BL[1]_47 BL[1]_48 BL[1]_49 BL[1]_50 BL[1]_51 BL[1]_52 BL[1]_53 BL[1]_54
+  BL[1]_55 BL[1]_56 BL[1]_57 BL[1]_58 BL[1]_59 BL[1]_60 BL[1]_61 BL[1]_62
+  BL[1]_63 BL[1]_64 BL[1]_65 BL[1]_66 BL[1]_67 BL[1]_68 BL[1]_69 BL[1]_70
+  BL[1]_71 BL[2]_36 BL[2]_37 BL[2]_38 BL[2]_39 BL[2]_40 BL[2]_41 BL[2]_42
+  BL[2]_43 BL[2]_44 BL[2]_45 BL[2]_46 BL[2]_47 BL[2]_48 BL[2]_49 BL[2]_50
+  BL[2]_51 BL[2]_52 BL[2]_53 BL[2]_54 BL[2]_55 BL[2]_56 BL[2]_57 BL[2]_58
+  BL[2]_59 BL[2]_60 BL[2]_61 BL[2]_62 BL[2]_63 BL[2]_64 BL[2]_65 BL[2]_66
+  BL[2]_67 BL[2]_68 BL[2]_69 BL[2]_70 BL[2]_71 BL[3]_36 BL[3]_37 BL[3]_38
+  BL[3]_39 BL[3]_40 BL[3]_41 BL[3]_42 BL[3]_43 BL[3]_44 BL[3]_45 BL[3]_46
+  BL[3]_47 BL[3]_48 BL[3]_49 BL[3]_50 BL[3]_51 BL[3]_52 BL[3]_53 BL[3]_54
+  BL[3]_55 BL[3]_56 BL[3]_57 BL[3]_58 BL[3]_59 BL[3]_60 BL[3]_61 BL[3]_62
+  BL[3]_63 BL[3]_64 BL[3]_65 BL[3]_66 BL[3]_67 BL[3]_68 BL[3]_69 BL[3]_70
+  BL[3]_71 NBL[0]_36 NBL[0]_37 NBL[0]_38 NBL[0]_39 NBL[0]_40 NBL[0]_41
+  NBL[0]_42 NBL[0]_43 NBL[0]_44 NBL[0]_45 NBL[0]_46 NBL[0]_47 NBL[0]_48
+  NBL[0]_49 NBL[0]_50 NBL[0]_51 NBL[0]_52 NBL[0]_53 NBL[0]_54 NBL[0]_55
+  NBL[0]_56 NBL[0]_57 NBL[0]_58 NBL[0]_59 NBL[0]_60 NBL[0]_61 NBL[0]_62
+  NBL[0]_63 NBL[0]_64 NBL[0]_65 NBL[0]_66 NBL[0]_67 NBL[0]_68 NBL[0]_69
+  NBL[0]_70 NBL[0]_71 NBL[1]_36 NBL[1]_37 NBL[1]_38 NBL[1]_39 NBL[1]_40
+  NBL[1]_41 NBL[1]_42 NBL[1]_43 NBL[1]_44 NBL[1]_45 NBL[1]_46 NBL[1]_47
+  NBL[1]_48 NBL[1]_49 NBL[1]_50 NBL[1]_51 NBL[1]_52 NBL[1]_53 NBL[1]_54
+  NBL[1]_55 NBL[1]_56 NBL[1]_57 NBL[1]_58 NBL[1]_59 NBL[1]_60 NBL[1]_61
+  NBL[1]_62 NBL[1]_63 NBL[1]_64 NBL[1]_65 NBL[1]_66 NBL[1]_67 NBL[1]_68
+  NBL[1]_69 NBL[1]_70 NBL[1]_71 NBL[2]_36 NBL[2]_37 NBL[2]_38 NBL[2]_39
+  NBL[2]_40 NBL[2]_41 NBL[2]_42 NBL[2]_43 NBL[2]_44 NBL[2]_45 NBL[2]_46
+  NBL[2]_47 NBL[2]_48 NBL[2]_49 NBL[2]_50 NBL[2]_51 NBL[2]_52 NBL[2]_53
+  NBL[2]_54 NBL[2]_55 NBL[2]_56 NBL[2]_57 NBL[2]_58 NBL[2]_59 NBL[2]_60
+  NBL[2]_61 NBL[2]_62 NBL[2]_63 NBL[2]_64 NBL[2]_65 NBL[2]_66 NBL[2]_67
+  NBL[2]_68 NBL[2]_69 NBL[2]_70 NBL[2]_71 NBL[3]_36 NBL[3]_37 NBL[3]_38
+  NBL[3]_39 NBL[3]_40 NBL[3]_41 NBL[3]_42 NBL[3]_43 NBL[3]_44 NBL[3]_45
+  NBL[3]_46 NBL[3]_47 NBL[3]_48 NBL[3]_49 NBL[3]_50 NBL[3]_51 NBL[3]_52
+  NBL[3]_53 NBL[3]_54 NBL[3]_55 NBL[3]_56 NBL[3]_57 NBL[3]_58 NBL[3]_59
+  NBL[3]_60 NBL[3]_61 NBL[3]_62 NBL[3]_63 NBL[3]_64 NBL[3]_65 NBL[3]_66
+  NBL[3]_67 NBL[3]_68 NBL[3]_69 NBL[3]_70 NBL[3]_71 VDDC VDDPE_37 VDDPE_38
+  VDDPE_39 VDDPE_40 VDDPE_41 VDDPE_42 VDDPE_43 VDDPE_44 VDDPE_45 VDDPE_46
+  VDDPE_47 VDDPE_48 VDDPE_49 VDDPE_50 VDDPE_51 VDDPE_52 VDDPE_53 VDDPE_54
+  VDDPE_55 VDDPE_56 VDDPE_57 VDDPE_58 VDDPE_59 VDDPE_60 VDDPE_61 VDDPE_62
+  VDDPE_63 VDDPE_64 VDDPE_65 VDDPE_66 VDDPE_67 VDDPE_68 VDDPE_69 VDDPE_70
+  VDDPE_71 VDDPE_72 VNWP_3 VNWP_4 VPW WL[0]_0 WL[0]_1 WL[0]_2 WL[0]_3 WL[0]_4
+  WL[0]_5 WL[0]_6 WL[0]_7 WL[0]_8 WL[0]_9 WL[0]_10 WL[0]_11 WL[0]_12 WL[0]_13
+  WL[0]_14 WL[0]_15 WL[0]_16 WL[0]_17 WL[0]_18 WL[0]_19 WL[0]_20 WL[0]_21
+  WL[0]_22 WL[0]_23 WL[0]_24 WL[0]_25 WL[0]_26 WL[0]_27 WL[0]_28 WL[0]_29
+  WL[0]_30 WL[0]_31 WL[0]_32 WL[0]_33 WL[0]_34 WL[0]_35 WL[0]_36 WL[0]_37
+  WL[0]_38 WL[0]_39 WL[0]_40 WL[0]_41 WL[0]_42 WL[0]_43 WL[0]_44 WL[0]_45
+  WL[0]_46 WL[0]_47 WL[0]_48 WL[0]_49 WL[0]_50 WL[0]_51 WL[0]_52 WL[0]_53
+  WL[0]_54 WL[0]_55 WL[0]_56 WL[0]_57 WL[0]_58 WL[0]_59 WL[0]_60 WL[0]_61
+  WL[0]_62 WL[0]_63 WL[0]_64 WL[0]_65 WL[0]_66 WL[0]_67 WL[0]_68 WL[0]_69
+  WL[0]_70 WL[0]_71 WL[0]_72 WL[0]_73 WL[0]_74 WL[0]_75 WL[0]_76 WL[0]_77
+  WL[0]_78 WL[0]_79 WL[0]_80 WL[0]_81 WL[0]_82 WL[0]_83 WL[0]_84 WL[0]_85
+  WL[0]_86 WL[0]_87 WL[0]_88 WL[0]_89 WL[0]_90 WL[0]_91 WL[0]_92 WL[0]_93
+  WL[0]_94 WL[0]_95 WL[0]_96 WL[0]_97 WL[0]_98 WL[0]_99 WL[0]_100 WL[0]_101
+  WL[0]_102 WL[0]_103 WL[0]_104 WL[0]_105 WL[0]_106 WL[0]_107 WL[0]_108
+  WL[0]_109 WL[0]_110 WL[0]_111 WL[0]_112 WL[0]_113 WL[0]_114 WL[0]_115
+  WL[1]_0 WL[1]_1 WL[1]_2 WL[1]_3 WL[1]_4 WL[1]_5 WL[1]_6 WL[1]_7 WL[1]_8
+  WL[1]_9 WL[1]_10 WL[1]_11 WL[1]_12 WL[1]_13 WL[1]_14 WL[1]_15 WL[1]_16
+  WL[1]_17 WL[1]_18 WL[1]_19 WL[1]_20 WL[1]_21 WL[1]_22 WL[1]_23 WL[1]_24
+  WL[1]_25 WL[1]_26 WL[1]_27 WL[1]_28 WL[1]_29 WL[1]_30 WL[1]_31 WL[1]_32
+  WL[1]_33 WL[1]_34 WL[1]_35 WL[1]_36 WL[1]_37 WL[1]_38 WL[1]_39 WL[1]_40
+  WL[1]_41 WL[1]_42 WL[1]_43 WL[1]_44 WL[1]_45 WL[1]_46 WL[1]_47 WL[1]_48
+  WL[1]_49 WL[1]_50 WL[1]_51 WL[1]_52 WL[1]_53 WL[1]_54 WL[1]_55 WL[1]_56
+  WL[1]_57 WL[1]_58 WL[1]_59 WL[1]_60 WL[1]_61 WL[1]_62 WL[1]_63 WL[1]_64
+  WL[1]_65 WL[1]_66 WL[1]_67 WL[1]_68 WL[1]_69 WL[1]_70 WL[1]_71 WL[1]_72
+  WL[1]_73 WL[1]_74 WL[1]_75 WL[1]_76 WL[1]_77 WL[1]_78 WL[1]_79 WL[1]_80
+  WL[1]_81 WL[1]_82 WL[1]_83 WL[1]_84 WL[1]_85 WL[1]_86 WL[1]_87 WL[1]_88
+  WL[1]_89 WL[1]_90 WL[1]_91 WL[1]_92 WL[1]_93 WL[1]_94 WL[1]_95 WL[1]_96
+  WL[1]_97 WL[1]_98 WL[1]_99 WL[1]_100 WL[1]_101 WL[1]_102 WL[1]_103
+  WL[1]_104 WL[1]_105 WL[1]_106 WL[1]_107 WL[1]_108 WL[1]_109 WL[1]_110
+  WL[1]_111 WL[1]_112 WL[1]_113 WL[1]_114 WL[1]_115 sram464x144MEMCORE_R
XWDDRVCOL A[0] A[1] A[2] A[3] A[4] A[5] BPGEN BRET1N BRET2N DBL DWL EMA0 EMA1
+  EMA2 GTPCLK0 GTPCLK1 LA_P2[0] LA_P2[1] LA_P2[2] LOG0 LOG0_DWL LOG1 NACT_CC
+  NGWE RET_0 RET_1 SAE_DUMMY VDDC VDDC VDDP VDDPE_36 VDDC VNWP_2 VPW WL[0]_0
+  WL[0]_32 WL[0]_33 WL[0]_34 WL[0]_35 WL[0]_36 WL[0]_37 WL[0]_38 WL[0]_39
+  WL[0]_40 WL[0]_41 WL[0]_42 WL[0]_43 WL[0]_44 WL[0]_45 WL[0]_46 WL[0]_47
+  WL[0]_48 WL[0]_49 WL[0]_50 WL[0]_51 WL[0]_52 WL[0]_53 WL[0]_54 WL[0]_55
+  WL[0]_56 WL[0]_57 WL[0]_58 WL[0]_59 WL[0]_60 WL[0]_61 WL[0]_62 WL[0]_63
+  WL[0]_64 WL[0]_65 WL[0]_66 WL[0]_67 WL[0]_68 WL[0]_69 WL[0]_70 WL[0]_71
+  WL[0]_72 WL[0]_73 WL[0]_74 WL[0]_75 WL[0]_76 WL[0]_77 WL[0]_78 WL[0]_79
+  WL[0]_80 WL[0]_81 WL[0]_82 WL[0]_83 WL[0]_84 WL[0]_85 WL[0]_86 WL[0]_87
+  WL[0]_88 WL[0]_89 WL[0]_90 WL[0]_91 WL[0]_92 WL[0]_93 WL[0]_94 WL[0]_95
+  WL[0]_96 WL[0]_97 WL[0]_98 WL[0]_99 WL[0]_100 WL[0]_101 WL[0]_102 WL[0]_103
+  WL[0]_104 WL[0]_105 WL[0]_106 WL[0]_107 WL[0]_108 WL[0]_109 WL[0]_110
+  WL[0]_111 WL[0]_112 WL[0]_113 WL[0]_114 WL[0]_115 WL[1]_0 WL[1]_32 WL[1]_33
+  WL[1]_34 WL[1]_35 WL[1]_36 WL[1]_37 WL[1]_38 WL[1]_39 WL[1]_40 WL[1]_41
+  WL[1]_42 WL[1]_43 WL[1]_44 WL[1]_45 WL[1]_46 WL[1]_47 WL[1]_48 WL[1]_49
+  WL[1]_50 WL[1]_51 WL[1]_52 WL[1]_53 WL[1]_54 WL[1]_55 WL[1]_56 WL[1]_57
+  WL[1]_58 WL[1]_59 WL[1]_60 WL[1]_61 WL[1]_62 WL[1]_63 WL[1]_64 WL[1]_65
+  WL[1]_66 WL[1]_67 WL[1]_68 WL[1]_69 WL[1]_70 WL[1]_71 WL[1]_72 WL[1]_73
+  WL[1]_74 WL[1]_75 WL[1]_76 WL[1]_77 WL[1]_78 WL[1]_79 WL[1]_80 WL[1]_81
+  WL[1]_82 WL[1]_83 WL[1]_84 WL[1]_85 WL[1]_86 WL[1]_87 WL[1]_88 WL[1]_89
+  WL[1]_90 WL[1]_91 WL[1]_92 WL[1]_93 WL[1]_94 WL[1]_95 WL[1]_96 WL[1]_97
+  WL[1]_98 WL[1]_99 WL[1]_100 WL[1]_101 WL[1]_102 WL[1]_103 WL[1]_104
+  WL[1]_105 WL[1]_106 WL[1]_107 WL[1]_108 WL[1]_109 WL[1]_110 WL[1]_111
+  WL[1]_112 WL[1]_113 WL[1]_114 WL[1]_115 WL[0]_1 WL[1]_1 WL[0]_2 WL[1]_2
+  WL[0]_3 WL[1]_3 WL[0]_4 WL[1]_4 WL[0]_5 WL[1]_5 WL[0]_6 WL[1]_6 WL[0]_7
+  WL[1]_7 WL[0]_8 WL[1]_8 WL[0]_9 WL[1]_9 WL[0]_10 WL[1]_10 WL[0]_11 WL[1]_11
+  WL[0]_12 WL[1]_12 WL[0]_13 WL[1]_13 WL[0]_14 WL[1]_14 WL[0]_15 WL[1]_15
+  WL[0]_16 WL[1]_16 WL[0]_17 WL[1]_17 WL[0]_18 WL[1]_18 WL[0]_19 WL[1]_19
+  WL[0]_20 WL[1]_20 WL[0]_21 WL[1]_21 WL[0]_22 WL[1]_22 WL[0]_23 WL[1]_23
+  WL[0]_24 WL[1]_24 WL[0]_25 WL[1]_25 WL[0]_26 WL[1]_26 WL[0]_27 WL[1]_27
+  WL[0]_28 WL[1]_28 WL[0]_29 WL[1]_29 WL[0]_30 WL[1]_30 WL[0]_31 WL[1]_31
+  sram464x144WDDRVCOL
.ENDS sram464x144MEM_SLICE
****
.SUBCKT sram464x144TILE_TOP CA0 CA1 CA2 CEN CLK D0_0 D0_1 D0_2 D0_3 D0_4 D0_5
+  D0_6 D0_7 D0_8 D0_9 D0_10 D0_11 D0_12 D0_13 D0_14 D0_15 D0_16 D0_17 D0_18
+  D0_19 D0_20 D0_21 D0_22 D0_23 D0_24 D0_25 D0_26 D0_27 D0_28 D0_29 D0_30
+  D0_31 D0_32 D0_33 D0_34 D0_35 D0_36 D0_37 D0_38 D0_39 D0_40 D0_41 D0_42
+  D0_43 D0_44 D0_45 D0_46 D0_47 D0_48 D0_49 D0_50 D0_51 D0_52 D0_53 D0_54
+  D0_55 D0_56 D0_57 D0_58 D0_59 D0_60 D0_61 D0_62 D0_63 D0_64 D0_65 D0_66
+  D0_67 D0_68 D0_69 D0_70 D0_71 D1_0 D1_1 D1_2 D1_3 D1_4 D1_5 D1_6 D1_7 D1_8
+  D1_9 D1_10 D1_11 D1_12 D1_13 D1_14 D1_15 D1_16 D1_17 D1_18 D1_19 D1_20
+  D1_21 D1_22 D1_23 D1_24 D1_25 D1_26 D1_27 D1_28 D1_29 D1_30 D1_31 D1_32
+  D1_33 D1_34 D1_35 D1_36 D1_37 D1_38 D1_39 D1_40 D1_41 D1_42 D1_43 D1_44
+  D1_45 D1_46 D1_47 D1_48 D1_49 D1_50 D1_51 D1_52 D1_53 D1_54 D1_55 D1_56
+  D1_57 D1_58 D1_59 D1_60 D1_61 D1_62 D1_63 D1_64 D1_65 D1_66 D1_67 D1_68
+  D1_69 D1_70 D1_71 EMA0 EMA1 EMA2 EMAW0 EMAW1 GWEN LA0 LA1 LA2 PSI Q0_0 Q0_1
+  Q0_2 Q0_3 Q0_4 Q0_5 Q0_6 Q0_7 Q0_8 Q0_9 Q0_10 Q0_11 Q0_12 Q0_13 Q0_14 Q0_15
+  Q0_16 Q0_17 Q0_18 Q0_19 Q0_20 Q0_21 Q0_22 Q0_23 Q0_24 Q0_25 Q0_26 Q0_27
+  Q0_28 Q0_29 Q0_30 Q0_31 Q0_32 Q0_33 Q0_34 Q0_35 Q0_36 Q0_37 Q0_38 Q0_39
+  Q0_40 Q0_41 Q0_42 Q0_43 Q0_44 Q0_45 Q0_46 Q0_47 Q0_48 Q0_49 Q0_50 Q0_51
+  Q0_52 Q0_53 Q0_54 Q0_55 Q0_56 Q0_57 Q0_58 Q0_59 Q0_60 Q0_61 Q0_62 Q0_63
+  Q0_64 Q0_65 Q0_66 Q0_67 Q0_68 Q0_69 Q0_70 Q0_71 Q1_0 Q1_1 Q1_2 Q1_3 Q1_4
+  Q1_5 Q1_6 Q1_7 Q1_8 Q1_9 Q1_10 Q1_11 Q1_12 Q1_13 Q1_14 Q1_15 Q1_16 Q1_17
+  Q1_18 Q1_19 Q1_20 Q1_21 Q1_22 Q1_23 Q1_24 Q1_25 Q1_26 Q1_27 Q1_28 Q1_29
+  Q1_30 Q1_31 Q1_32 Q1_33 Q1_34 Q1_35 Q1_36 Q1_37 Q1_38 Q1_39 Q1_40 Q1_41
+  Q1_42 Q1_43 Q1_44 Q1_45 Q1_46 Q1_47 Q1_48 Q1_49 Q1_50 Q1_51 Q1_52 Q1_53
+  Q1_54 Q1_55 Q1_56 Q1_57 Q1_58 Q1_59 Q1_60 Q1_61 Q1_62 Q1_63 Q1_64 Q1_65
+  Q1_66 Q1_67 Q1_68 Q1_69 Q1_70 Q1_71 RA0 RA1 RA2 RA3 RA4 RA5 RET1N VDDC_L
+  VDDPE VPW WEN0_0 WEN0_1 WEN0_2 WEN0_3 WEN0_4 WEN0_5 WEN0_6 WEN0_7 WEN0_8
+  WEN0_9 WEN0_10 WEN0_11 WEN0_12 WEN0_13 WEN0_14 WEN0_15 WEN0_16 WEN0_17
+  WEN0_18 WEN0_19 WEN0_20 WEN0_21 WEN0_22 WEN0_23 WEN0_24 WEN0_25 WEN0_26
+  WEN0_27 WEN0_28 WEN0_29 WEN0_30 WEN0_31 WEN0_32 WEN0_33 WEN0_34 WEN0_35
+  WEN0_36 WEN0_37 WEN0_38 WEN0_39 WEN0_40 WEN0_41 WEN0_42 WEN0_43 WEN0_44
+  WEN0_45 WEN0_46 WEN0_47 WEN0_48 WEN0_49 WEN0_50 WEN0_51 WEN0_52 WEN0_53
+  WEN0_54 WEN0_55 WEN0_56 WEN0_57 WEN0_58 WEN0_59 WEN0_60 WEN0_61 WEN0_62
+  WEN0_63 WEN0_64 WEN0_65 WEN0_66 WEN0_67 WEN0_68 WEN0_69 WEN0_70 WEN0_71
+  WEN1_0 WEN1_1 WEN1_2 WEN1_3 WEN1_4 WEN1_5 WEN1_6 WEN1_7 WEN1_8 WEN1_9
+  WEN1_10 WEN1_11 WEN1_12 WEN1_13 WEN1_14 WEN1_15 WEN1_16 WEN1_17 WEN1_18
+  WEN1_19 WEN1_20 WEN1_21 WEN1_22 WEN1_23 WEN1_24 WEN1_25 WEN1_26 WEN1_27
+  WEN1_28 WEN1_29 WEN1_30 WEN1_31 WEN1_32 WEN1_33 WEN1_34 WEN1_35 WEN1_36
+  WEN1_37 WEN1_38 WEN1_39 WEN1_40 WEN1_41 WEN1_42 WEN1_43 WEN1_44 WEN1_45
+  WEN1_46 WEN1_47 WEN1_48 WEN1_49 WEN1_50 WEN1_51 WEN1_52 WEN1_53 WEN1_54
+  WEN1_55 WEN1_56 WEN1_57 WEN1_58 WEN1_59 WEN1_60 WEN1_61 WEN1_62 WEN1_63
+  WEN1_64 WEN1_65 WEN1_66 WEN1_67 WEN1_68 WEN1_69 WEN1_70 WEN1_71 WENY0_0
+  WENY0_1 WENY0_2 WENY0_3 WENY0_4 WENY0_5 WENY0_6 WENY0_7 WENY0_8 WENY0_9
+  WENY0_10 WENY0_11 WENY0_12 WENY0_13 WENY0_14 WENY0_15 WENY0_16 WENY0_17
+  WENY0_18 WENY0_19 WENY0_20 WENY0_21 WENY0_22 WENY0_23 WENY0_24 WENY0_25
+  WENY0_26 WENY0_27 WENY0_28 WENY0_29 WENY0_30 WENY0_31 WENY0_32 WENY0_33
+  WENY0_34 WENY0_35 WENY0_36 WENY0_37 WENY0_38 WENY0_39 WENY0_40 WENY0_41
+  WENY0_42 WENY0_43 WENY0_44 WENY0_45 WENY0_46 WENY0_47 WENY0_48 WENY0_49
+  WENY0_50 WENY0_51 WENY0_52 WENY0_53 WENY0_54 WENY0_55 WENY0_56 WENY0_57
+  WENY0_58 WENY0_59 WENY0_60 WENY0_61 WENY0_62 WENY0_63 WENY0_64 WENY0_65
+  WENY0_66 WENY0_67 WENY0_68 WENY0_69 WENY0_70 WENY0_71 WENY1_0 WENY1_1
+  WENY1_2 WENY1_3 WENY1_4 WENY1_5 WENY1_6 WENY1_7 WENY1_8 WENY1_9 WENY1_10
+  WENY1_11 WENY1_12 WENY1_13 WENY1_14 WENY1_15 WENY1_16 WENY1_17 WENY1_18
+  WENY1_19 WENY1_20 WENY1_21 WENY1_22 WENY1_23 WENY1_24 WENY1_25 WENY1_26
+  WENY1_27 WENY1_28 WENY1_29 WENY1_30 WENY1_31 WENY1_32 WENY1_33 WENY1_34
+  WENY1_35 WENY1_36 WENY1_37 WENY1_38 WENY1_39 WENY1_40 WENY1_41 WENY1_42
+  WENY1_43 WENY1_44 WENY1_45 WENY1_46 WENY1_47 WENY1_48 WENY1_49 WENY1_50
+  WENY1_51 WENY1_52 WENY1_53 WENY1_54 WENY1_55 WENY1_56 WENY1_57 WENY1_58
+  WENY1_59 WENY1_60 WENY1_61 WENY1_62 WENY1_63 WENY1_64 WENY1_65 WENY1_66
+  WENY1_67 WENY1_68 WENY1_69 WENY1_70 WENY1_71
** sram464x144TILE_TOP: 421912 flat devices **
XBOTCAP CA0 CA1 CA2 CEN CLK D0_0 D0_1 D0_2 D0_3 D0_4 D0_5 D0_6 D0_7 D0_8 D0_9
+  D0_10 D0_11 D0_12 D0_13 D0_14 D0_15 D0_16 D0_17 D0_18 D0_19 D0_20 D0_21
+  D0_22 D0_23 D0_24 D0_25 D0_26 D0_27 D0_28 D0_29 D0_30 D0_31 D0_32 D0_33
+  D0_34 D0_35 D0_36 D0_37 D0_38 D0_39 D0_40 D0_41 D0_42 D0_43 D0_44 D0_45
+  D0_46 D0_47 D0_48 D0_49 D0_50 D0_51 D0_52 D0_53 D0_54 D0_55 D0_56 D0_57
+  D0_58 D0_59 D0_60 D0_61 D0_62 D0_63 D0_64 D0_65 D0_66 D0_67 D0_68 D0_69
+  D0_70 D0_71 D1_0 D1_1 D1_2 D1_3 D1_4 D1_5 D1_6 D1_7 D1_8 D1_9 D1_10 D1_11
+  D1_12 D1_13 D1_14 D1_15 D1_16 D1_17 D1_18 D1_19 D1_20 D1_21 D1_22 D1_23
+  D1_24 D1_25 D1_26 D1_27 D1_28 D1_29 D1_30 D1_31 D1_32 D1_33 D1_34 D1_35
+  D1_36 D1_37 D1_38 D1_39 D1_40 D1_41 D1_42 D1_43 D1_44 D1_45 D1_46 D1_47
+  D1_48 D1_49 D1_50 D1_51 D1_52 D1_53 D1_54 D1_55 D1_56 D1_57 D1_58 D1_59
+  D1_60 D1_61 D1_62 D1_63 D1_64 D1_65 D1_66 D1_67 D1_68 D1_69 D1_70 D1_71
+  DUM_ACTP DUM_NACTC DUM_RETNVT EMA0 EMA1 EMA2 EMAW0 EMAW1 GWEN LA0 LA1 LA2
+  PSI PSI PSI Q0_0 Q0_1 Q0_2 Q0_3 Q0_4 Q0_5 Q0_6 Q0_7 Q0_8 Q0_9 Q0_10 Q0_11
+  Q0_12 Q0_13 Q0_14 Q0_15 Q0_16 Q0_17 Q0_18 Q0_19 Q0_20 Q0_21 Q0_22 Q0_23
+  Q0_24 Q0_25 Q0_26 Q0_27 Q0_28 Q0_29 Q0_30 Q0_31 Q0_32 Q0_33 Q0_34 Q0_35
+  Q0_36 Q0_37 Q0_38 Q0_39 Q0_40 Q0_41 Q0_42 Q0_43 Q0_44 Q0_45 Q0_46 Q0_47
+  Q0_48 Q0_49 Q0_50 Q0_51 Q0_52 Q0_53 Q0_54 Q0_55 Q0_56 Q0_57 Q0_58 Q0_59
+  Q0_60 Q0_61 Q0_62 Q0_63 Q0_64 Q0_65 Q0_66 Q0_67 Q0_68 Q0_69 Q0_70 Q0_71
+  Q1_0 Q1_1 Q1_2 Q1_3 Q1_4 Q1_5 Q1_6 Q1_7 Q1_8 Q1_9 Q1_10 Q1_11 Q1_12 Q1_13
+  Q1_14 Q1_15 Q1_16 Q1_17 Q1_18 Q1_19 Q1_20 Q1_21 Q1_22 Q1_23 Q1_24 Q1_25
+  Q1_26 Q1_27 Q1_28 Q1_29 Q1_30 Q1_31 Q1_32 Q1_33 Q1_34 Q1_35 Q1_36 Q1_37
+  Q1_38 Q1_39 Q1_40 Q1_41 Q1_42 Q1_43 Q1_44 Q1_45 Q1_46 Q1_47 Q1_48 Q1_49
+  Q1_50 Q1_51 Q1_52 Q1_53 Q1_54 Q1_55 Q1_56 Q1_57 Q1_58 Q1_59 Q1_60 Q1_61
+  Q1_62 Q1_63 Q1_64 Q1_65 Q1_66 Q1_67 Q1_68 Q1_69 Q1_70 Q1_71 RA0 RA1 RA2 RA3
+  RA4 RA5 PSI RET1N PSI PSI VDDC_L VDDC_L VDDC_L VDDC_L VDDC_L VDDC_L VDDC_L
+  VDDC_L VDDC_L VDDC_L VDDC_L VDDC_L VDDC_L VDDC_L VDDC_L VDDC_L VDDC_L
+  VDDC_L VDDC_L VDDC_L VDDC_L VDDC_L VDDC_L VDDC_L VDDC_L VDDC_L VDDC_L
+  VDDC_L VDDC_L VDDC_L VDDC_L VDDC_L VDDC_L VDDC_L VDDC_L VDDC_L VDDC_L
+  VDDC_L VDDC_L VDDC_L VDDC_L VDDC_L VDDC_L VDDC_L VDDC_L VDDC_L VDDC_L
+  VDDC_L VDDC_L VDDC_L VDDC_L VDDC_L VDDC_L VDDC_L VDDC_L VDDC_L VDDC_L
+  VDDC_L VDDC_L VDDC_L VDDC_L VDDC_L VDDC_L VDDC_L VDDC_L VDDC_L VDDC_L
+  VDDC_L VDDC_L VDDC_L VDDC_L VDDC_L VDDC_L VDDC_L VDDC_L VDDPE VDDPE VDDC_L
+  VDDC_L VDDC_L VDDPE VPW VPW WEN0_0 WEN0_1 WEN0_2 WEN0_3 WEN0_4 WEN0_5
+  WEN0_6 WEN0_7 WEN0_8 WEN0_9 WEN0_10 WEN0_11 WEN0_12 WEN0_13 WEN0_14 WEN0_15
+  WEN0_16 WEN0_17 WEN0_18 WEN0_19 WEN0_20 WEN0_21 WEN0_22 WEN0_23 WEN0_24
+  WEN0_25 WEN0_26 WEN0_27 WEN0_28 WEN0_29 WEN0_30 WEN0_31 WEN0_32 WEN0_33
+  WEN0_34 WEN0_35 WEN0_36 WEN0_37 WEN0_38 WEN0_39 WEN0_40 WEN0_41 WEN0_42
+  WEN0_43 WEN0_44 WEN0_45 WEN0_46 WEN0_47 WEN0_48 WEN0_49 WEN0_50 WEN0_51
+  WEN0_52 WEN0_53 WEN0_54 WEN0_55 WEN0_56 WEN0_57 WEN0_58 WEN0_59 WEN0_60
+  WEN0_61 WEN0_62 WEN0_63 WEN0_64 WEN0_65 WEN0_66 WEN0_67 WEN0_68 WEN0_69
+  WEN0_70 WEN0_71 WEN1_0 WEN1_1 WEN1_2 WEN1_3 WEN1_4 WEN1_5 WEN1_6 WEN1_7
+  WEN1_8 WEN1_9 WEN1_10 WEN1_11 WEN1_12 WEN1_13 WEN1_14 WEN1_15 WEN1_16
+  WEN1_17 WEN1_18 WEN1_19 WEN1_20 WEN1_21 WEN1_22 WEN1_23 WEN1_24 WEN1_25
+  WEN1_26 WEN1_27 WEN1_28 WEN1_29 WEN1_30 WEN1_31 WEN1_32 WEN1_33 WEN1_34
+  WEN1_35 WEN1_36 WEN1_37 WEN1_38 WEN1_39 WEN1_40 WEN1_41 WEN1_42 WEN1_43
+  WEN1_44 WEN1_45 WEN1_46 WEN1_47 WEN1_48 WEN1_49 WEN1_50 WEN1_51 WEN1_52
+  WEN1_53 WEN1_54 WEN1_55 WEN1_56 WEN1_57 WEN1_58 WEN1_59 WEN1_60 WEN1_61
+  WEN1_62 WEN1_63 WEN1_64 WEN1_65 WEN1_66 WEN1_67 WEN1_68 WEN1_69 WEN1_70
+  WEN1_71 WENY0_0 WENY0_1 WENY0_2 WENY0_3 WENY0_4 WENY0_5 WENY0_6 WENY0_7
+  WENY0_8 WENY0_9 WENY0_10 WENY0_11 WENY0_12 WENY0_13 WENY0_14 WENY0_15
+  WENY0_16 WENY0_17 WENY0_18 WENY0_19 WENY0_20 WENY0_21 WENY0_22 WENY0_23
+  WENY0_24 WENY0_25 WENY0_26 WENY0_27 WENY0_28 WENY0_29 WENY0_30 WENY0_31
+  WENY0_32 WENY0_33 WENY0_34 WENY0_35 WENY0_36 WENY0_37 WENY0_38 WENY0_39
+  WENY0_40 WENY0_41 WENY0_42 WENY0_43 WENY0_44 WENY0_45 WENY0_46 WENY0_47
+  WENY0_48 WENY0_49 WENY0_50 WENY0_51 WENY0_52 WENY0_53 WENY0_54 WENY0_55
+  WENY0_56 WENY0_57 WENY0_58 WENY0_59 WENY0_60 WENY0_61 WENY0_62 WENY0_63
+  WENY0_64 WENY0_65 WENY0_66 WENY0_67 WENY0_68 WENY0_69 WENY0_70 WENY0_71
+  WENY1_0 WENY1_1 WENY1_2 WENY1_3 WENY1_4 WENY1_5 WENY1_6 WENY1_7 WENY1_8
+  WENY1_9 WENY1_10 WENY1_11 WENY1_12 WENY1_13 WENY1_14 WENY1_15 WENY1_16
+  WENY1_17 WENY1_18 WENY1_19 WENY1_20 WENY1_21 WENY1_22 WENY1_23 WENY1_24
+  WENY1_25 WENY1_26 WENY1_27 WENY1_28 WENY1_29 WENY1_30 WENY1_31 WENY1_32
+  WENY1_33 WENY1_34 WENY1_35 WENY1_36 WENY1_37 WENY1_38 WENY1_39 WENY1_40
+  WENY1_41 WENY1_42 WENY1_43 WENY1_44 WENY1_45 WENY1_46 WENY1_47 WENY1_48
+  WENY1_49 WENY1_50 WENY1_51 WENY1_52 WENY1_53 WENY1_54 WENY1_55 WENY1_56
+  WENY1_57 WENY1_58 WENY1_59 WENY1_60 WENY1_61 WENY1_62 WENY1_63 WENY1_64
+  WENY1_65 WENY1_66 WENY1_67 WENY1_68 WENY1_69 WENY1_70 WENY1_71
+  sram464x144BOTCAPROW
XIO_SLICE DUM_ACTP BL[0]_0 BL[0]_1 BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6
+  BL[0]_7 BL[0]_8 BL[0]_9 BL[0]_10 BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14
+  BL[0]_15 BL[0]_16 BL[0]_17 BL[0]_18 BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22
+  BL[0]_23 BL[0]_24 BL[0]_25 BL[0]_26 BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30
+  BL[0]_31 BL[0]_32 BL[0]_33 BL[0]_34 BL[0]_35 BL[0]_36 BL[0]_37 BL[0]_38
+  BL[0]_39 BL[0]_40 BL[0]_41 BL[0]_42 BL[0]_43 BL[0]_44 BL[0]_45 BL[0]_46
+  BL[0]_47 BL[0]_48 BL[0]_49 BL[0]_50 BL[0]_51 BL[0]_52 BL[0]_53 BL[0]_54
+  BL[0]_55 BL[0]_56 BL[0]_57 BL[0]_58 BL[0]_59 BL[0]_60 BL[0]_61 BL[0]_62
+  BL[0]_63 BL[0]_64 BL[0]_65 BL[0]_66 BL[0]_67 BL[0]_68 BL[0]_69 BL[0]_70
+  BL[0]_71 BL[1]_0 BL[1]_1 BL[1]_2 BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7
+  BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11 BL[1]_12 BL[1]_13 BL[1]_14 BL[1]_15
+  BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19 BL[1]_20 BL[1]_21 BL[1]_22 BL[1]_23
+  BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27 BL[1]_28 BL[1]_29 BL[1]_30 BL[1]_31
+  BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35 BL[1]_36 BL[1]_37 BL[1]_38 BL[1]_39
+  BL[1]_40 BL[1]_41 BL[1]_42 BL[1]_43 BL[1]_44 BL[1]_45 BL[1]_46 BL[1]_47
+  BL[1]_48 BL[1]_49 BL[1]_50 BL[1]_51 BL[1]_52 BL[1]_53 BL[1]_54 BL[1]_55
+  BL[1]_56 BL[1]_57 BL[1]_58 BL[1]_59 BL[1]_60 BL[1]_61 BL[1]_62 BL[1]_63
+  BL[1]_64 BL[1]_65 BL[1]_66 BL[1]_67 BL[1]_68 BL[1]_69 BL[1]_70 BL[1]_71
+  BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4 BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8
+  BL[2]_9 BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13 BL[2]_14 BL[2]_15 BL[2]_16
+  BL[2]_17 BL[2]_18 BL[2]_19 BL[2]_20 BL[2]_21 BL[2]_22 BL[2]_23 BL[2]_24
+  BL[2]_25 BL[2]_26 BL[2]_27 BL[2]_28 BL[2]_29 BL[2]_30 BL[2]_31 BL[2]_32
+  BL[2]_33 BL[2]_34 BL[2]_35 BL[2]_36 BL[2]_37 BL[2]_38 BL[2]_39 BL[2]_40
+  BL[2]_41 BL[2]_42 BL[2]_43 BL[2]_44 BL[2]_45 BL[2]_46 BL[2]_47 BL[2]_48
+  BL[2]_49 BL[2]_50 BL[2]_51 BL[2]_52 BL[2]_53 BL[2]_54 BL[2]_55 BL[2]_56
+  BL[2]_57 BL[2]_58 BL[2]_59 BL[2]_60 BL[2]_61 BL[2]_62 BL[2]_63 BL[2]_64
+  BL[2]_65 BL[2]_66 BL[2]_67 BL[2]_68 BL[2]_69 BL[2]_70 BL[2]_71 BL[3]_0
+  BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6 BL[3]_7 BL[3]_8 BL[3]_9
+  BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14 BL[3]_15 BL[3]_16 BL[3]_17
+  BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22 BL[3]_23 BL[3]_24 BL[3]_25
+  BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30 BL[3]_31 BL[3]_32 BL[3]_33
+  BL[3]_34 BL[3]_35 BL[3]_36 BL[3]_37 BL[3]_38 BL[3]_39 BL[3]_40 BL[3]_41
+  BL[3]_42 BL[3]_43 BL[3]_44 BL[3]_45 BL[3]_46 BL[3]_47 BL[3]_48 BL[3]_49
+  BL[3]_50 BL[3]_51 BL[3]_52 BL[3]_53 BL[3]_54 BL[3]_55 BL[3]_56 BL[3]_57
+  BL[3]_58 BL[3]_59 BL[3]_60 BL[3]_61 BL[3]_62 BL[3]_63 BL[3]_64 BL[3]_65
+  BL[3]_66 BL[3]_67 BL[3]_68 BL[3]_69 BL[3]_70 BL[3]_71 CA0 CA1 CA2 CEN CLK
+  D0_0 D0_1 D0_2 D0_3 D0_4 D0_5 D0_6 D0_7 D0_8 D0_9 D0_10 D0_11 D0_12 D0_13
+  D0_14 D0_15 D0_16 D0_17 D0_18 D0_19 D0_20 D0_21 D0_22 D0_23 D0_24 D0_25
+  D0_26 D0_27 D0_28 D0_29 D0_30 D0_31 D0_32 D0_33 D0_34 D0_35 D0_36 D0_37
+  D0_38 D0_39 D0_40 D0_41 D0_42 D0_43 D0_44 D0_45 D0_46 D0_47 D0_48 D0_49
+  D0_50 D0_51 D0_52 D0_53 D0_54 D0_55 D0_56 D0_57 D0_58 D0_59 D0_60 D0_61
+  D0_62 D0_63 D0_64 D0_65 D0_66 D0_67 D0_68 D0_69 D0_70 D0_71 D1_0 D1_1 D1_2
+  D1_3 D1_4 D1_5 D1_6 D1_7 D1_8 D1_9 D1_10 D1_11 D1_12 D1_13 D1_14 D1_15
+  D1_16 D1_17 D1_18 D1_19 D1_20 D1_21 D1_22 D1_23 D1_24 D1_25 D1_26 D1_27
+  D1_28 D1_29 D1_30 D1_31 D1_32 D1_33 D1_34 D1_35 D1_36 D1_37 D1_38 D1_39
+  D1_40 D1_41 D1_42 D1_43 D1_44 D1_45 D1_46 D1_47 D1_48 D1_49 D1_50 D1_51
+  D1_52 D1_53 D1_54 D1_55 D1_56 D1_57 D1_58 D1_59 D1_60 D1_61 D1_62 D1_63
+  D1_64 D1_65 D1_66 D1_67 D1_68 D1_69 D1_70 D1_71 DBL DWL EMAW0 EMAW1 EMA0
+  EMA1 EMA2 GTP GWEN LA0 LA1 LA2 LA_P2[0] LA_P2[1] LA_P2[2] PSI PSI PSI
+  LOG0_DWL LOG1 DUM_NACTC NACT_CC NBL[0]_0 NBL[0]_1 NBL[0]_2 NBL[0]_3
+  NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9 NBL[0]_10 NBL[0]_11
+  NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16 NBL[0]_17 NBL[0]_18
+  NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23 NBL[0]_24 NBL[0]_25
+  NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30 NBL[0]_31 NBL[0]_32
+  NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[0]_36 NBL[0]_37 NBL[0]_38 NBL[0]_39
+  NBL[0]_40 NBL[0]_41 NBL[0]_42 NBL[0]_43 NBL[0]_44 NBL[0]_45 NBL[0]_46
+  NBL[0]_47 NBL[0]_48 NBL[0]_49 NBL[0]_50 NBL[0]_51 NBL[0]_52 NBL[0]_53
+  NBL[0]_54 NBL[0]_55 NBL[0]_56 NBL[0]_57 NBL[0]_58 NBL[0]_59 NBL[0]_60
+  NBL[0]_61 NBL[0]_62 NBL[0]_63 NBL[0]_64 NBL[0]_65 NBL[0]_66 NBL[0]_67
+  NBL[0]_68 NBL[0]_69 NBL[0]_70 NBL[0]_71 NBL[1]_0 NBL[1]_1 NBL[1]_2 NBL[1]_3
+  NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8 NBL[1]_9 NBL[1]_10 NBL[1]_11
+  NBL[1]_12 NBL[1]_13 NBL[1]_14 NBL[1]_15 NBL[1]_16 NBL[1]_17 NBL[1]_18
+  NBL[1]_19 NBL[1]_20 NBL[1]_21 NBL[1]_22 NBL[1]_23 NBL[1]_24 NBL[1]_25
+  NBL[1]_26 NBL[1]_27 NBL[1]_28 NBL[1]_29 NBL[1]_30 NBL[1]_31 NBL[1]_32
+  NBL[1]_33 NBL[1]_34 NBL[1]_35 NBL[1]_36 NBL[1]_37 NBL[1]_38 NBL[1]_39
+  NBL[1]_40 NBL[1]_41 NBL[1]_42 NBL[1]_43 NBL[1]_44 NBL[1]_45 NBL[1]_46
+  NBL[1]_47 NBL[1]_48 NBL[1]_49 NBL[1]_50 NBL[1]_51 NBL[1]_52 NBL[1]_53
+  NBL[1]_54 NBL[1]_55 NBL[1]_56 NBL[1]_57 NBL[1]_58 NBL[1]_59 NBL[1]_60
+  NBL[1]_61 NBL[1]_62 NBL[1]_63 NBL[1]_64 NBL[1]_65 NBL[1]_66 NBL[1]_67
+  NBL[1]_68 NBL[1]_69 NBL[1]_70 NBL[1]_71 NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3
+  NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7 NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11
+  NBL[2]_12 NBL[2]_13 NBL[2]_14 NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18
+  NBL[2]_19 NBL[2]_20 NBL[2]_21 NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25
+  NBL[2]_26 NBL[2]_27 NBL[2]_28 NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32
+  NBL[2]_33 NBL[2]_34 NBL[2]_35 NBL[2]_36 NBL[2]_37 NBL[2]_38 NBL[2]_39
+  NBL[2]_40 NBL[2]_41 NBL[2]_42 NBL[2]_43 NBL[2]_44 NBL[2]_45 NBL[2]_46
+  NBL[2]_47 NBL[2]_48 NBL[2]_49 NBL[2]_50 NBL[2]_51 NBL[2]_52 NBL[2]_53
+  NBL[2]_54 NBL[2]_55 NBL[2]_56 NBL[2]_57 NBL[2]_58 NBL[2]_59 NBL[2]_60
+  NBL[2]_61 NBL[2]_62 NBL[2]_63 NBL[2]_64 NBL[2]_65 NBL[2]_66 NBL[2]_67
+  NBL[2]_68 NBL[2]_69 NBL[2]_70 NBL[2]_71 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3
+  NBL[3]_4 NBL[3]_5 NBL[3]_6 NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11
+  NBL[3]_12 NBL[3]_13 NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18
+  NBL[3]_19 NBL[3]_20 NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25
+  NBL[3]_26 NBL[3]_27 NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32
+  NBL[3]_33 NBL[3]_34 NBL[3]_35 NBL[3]_36 NBL[3]_37 NBL[3]_38 NBL[3]_39
+  NBL[3]_40 NBL[3]_41 NBL[3]_42 NBL[3]_43 NBL[3]_44 NBL[3]_45 NBL[3]_46
+  NBL[3]_47 NBL[3]_48 NBL[3]_49 NBL[3]_50 NBL[3]_51 NBL[3]_52 NBL[3]_53
+  NBL[3]_54 NBL[3]_55 NBL[3]_56 NBL[3]_57 NBL[3]_58 NBL[3]_59 NBL[3]_60
+  NBL[3]_61 NBL[3]_62 NBL[3]_63 NBL[3]_64 NBL[3]_65 NBL[3]_66 NBL[3]_67
+  NBL[3]_68 NBL[3]_69 NBL[3]_70 NBL[3]_71 NGWE DUM_RETNVT Q0_0 Q0_1 Q0_2 Q0_3
+  Q0_4 Q0_5 Q0_6 Q0_7 Q0_8 Q0_9 Q0_10 Q0_11 Q0_12 Q0_13 Q0_14 Q0_15 Q0_16
+  Q0_17 Q0_18 Q0_19 Q0_20 Q0_21 Q0_22 Q0_23 Q0_24 Q0_25 Q0_26 Q0_27 Q0_28
+  Q0_29 Q0_30 Q0_31 Q0_32 Q0_33 Q0_34 Q0_35 Q0_36 Q0_37 Q0_38 Q0_39 Q0_40
+  Q0_41 Q0_42 Q0_43 Q0_44 Q0_45 Q0_46 Q0_47 Q0_48 Q0_49 Q0_50 Q0_51 Q0_52
+  Q0_53 Q0_54 Q0_55 Q0_56 Q0_57 Q0_58 Q0_59 Q0_60 Q0_61 Q0_62 Q0_63 Q0_64
+  Q0_65 Q0_66 Q0_67 Q0_68 Q0_69 Q0_70 Q0_71 Q1_0 Q1_1 Q1_2 Q1_3 Q1_4 Q1_5
+  Q1_6 Q1_7 Q1_8 Q1_9 Q1_10 Q1_11 Q1_12 Q1_13 Q1_14 Q1_15 Q1_16 Q1_17 Q1_18
+  Q1_19 Q1_20 Q1_21 Q1_22 Q1_23 Q1_24 Q1_25 Q1_26 Q1_27 Q1_28 Q1_29 Q1_30
+  Q1_31 Q1_32 Q1_33 Q1_34 Q1_35 Q1_36 Q1_37 Q1_38 Q1_39 Q1_40 Q1_41 Q1_42
+  Q1_43 Q1_44 Q1_45 Q1_46 Q1_47 Q1_48 Q1_49 Q1_50 Q1_51 Q1_52 Q1_53 Q1_54
+  Q1_55 Q1_56 Q1_57 Q1_58 Q1_59 Q1_60 Q1_61 Q1_62 Q1_63 Q1_64 Q1_65 Q1_66
+  Q1_67 Q1_68 Q1_69 Q1_70 Q1_71 RA0 RA1 RA2 RA3 RA4 RA5 RA_P2[0] RA_P2[1]
+  RA_P2[2] RA_P2[3] RA_P2[4] RET RET1N SAE_DUMMY PSI PSI PSI PSI PSI PSI PSI
+  PSI PSI PSI PSI PSI PSI PSI PSI PSI PSI PSI PSI PSI PSI PSI PSI PSI PSI PSI
+  PSI PSI PSI PSI PSI PSI PSI PSI PSI PSI PSI PSI PSI PSI PSI PSI PSI PSI PSI
+  PSI PSI PSI PSI PSI PSI PSI PSI PSI PSI PSI PSI PSI PSI PSI PSI PSI PSI PSI
+  PSI PSI PSI PSI PSI PSI PSI PSI PSI PSI PSI PSI PSI PSI PSI PSI PSI PSI PSI
+  PSI PSI PSI PSI PSI PSI PSI PSI PSI PSI PSI PSI PSI PSI PSI PSI PSI PSI PSI
+  PSI PSI PSI PSI PSI PSI PSI PSI PSI PSI PSI PSI PSI PSI PSI PSI PSI PSI PSI
+  PSI PSI PSI PSI PSI PSI PSI PSI PSI PSI PSI PSI PSI PSI PSI PSI PSI PSI PSI
+  PSI PSI PSI PSI PSI PSI PSI PSI PSI PSI PSI PSI PSI PSI PSI PSI PSI PSI PSI
+  PSI PSI PSI PSI PSI PSI PSI PSI PSI PSI PSI PSI PSI PSI PSI PSI PSI PSI PSI
+  PSI PSI PSI PSI PSI PSI PSI PSI PSI PSI PSI PSI PSI PSI PSI PSI PSI PSI PSI
+  PSI PSI PSI PSI PSI PSI PSI PSI PSI PSI PSI PSI PSI PSI PSI PSI PSI PSI PSI
+  PSI PSI PSI PSI PSI PSI PSI PSI PSI PSI PSI PSI PSI PSI PSI PSI PSI PSI PSI
+  PSI PSI PSI PSI PSI PSI PSI PSI PSI PSI PSI PSI PSI PSI PSI PSI PSI PSI PSI
+  PSI PSI PSI PSI PSI PSI PSI PSI PSI PSI PSI PSI PSI PSI PSI PSI PSI PSI PSI
+  PSI PSI PSI PSI PSI PSI PSI PSI PSI PSI PSI PSI PSI PSI PSI VDDC_L VDDP
+  VDDPE VPW WEN0_0 WEN0_1 WEN0_2 WEN0_3 WEN0_4 WEN0_5 WEN0_6 WEN0_7 WEN0_8
+  WEN0_9 WEN0_10 WEN0_11 WEN0_12 WEN0_13 WEN0_14 WEN0_15 WEN0_16 WEN0_17
+  WEN0_18 WEN0_19 WEN0_20 WEN0_21 WEN0_22 WEN0_23 WEN0_24 WEN0_25 WEN0_26
+  WEN0_27 WEN0_28 WEN0_29 WEN0_30 WEN0_31 WEN0_32 WEN0_33 WEN0_34 WEN0_35
+  WEN0_36 WEN0_37 WEN0_38 WEN0_39 WEN0_40 WEN0_41 WEN0_42 WEN0_43 WEN0_44
+  WEN0_45 WEN0_46 WEN0_47 WEN0_48 WEN0_49 WEN0_50 WEN0_51 WEN0_52 WEN0_53
+  WEN0_54 WEN0_55 WEN0_56 WEN0_57 WEN0_58 WEN0_59 WEN0_60 WEN0_61 WEN0_62
+  WEN0_63 WEN0_64 WEN0_65 WEN0_66 WEN0_67 WEN0_68 WEN0_69 WEN0_70 WEN0_71
+  WEN1_0 WEN1_1 WEN1_2 WEN1_3 WEN1_4 WEN1_5 WEN1_6 WEN1_7 WEN1_8 WEN1_9
+  WEN1_10 WEN1_11 WEN1_12 WEN1_13 WEN1_14 WEN1_15 WEN1_16 WEN1_17 WEN1_18
+  WEN1_19 WEN1_20 WEN1_21 WEN1_22 WEN1_23 WEN1_24 WEN1_25 WEN1_26 WEN1_27
+  WEN1_28 WEN1_29 WEN1_30 WEN1_31 WEN1_32 WEN1_33 WEN1_34 WEN1_35 WEN1_36
+  WEN1_37 WEN1_38 WEN1_39 WEN1_40 WEN1_41 WEN1_42 WEN1_43 WEN1_44 WEN1_45
+  WEN1_46 WEN1_47 WEN1_48 WEN1_49 WEN1_50 WEN1_51 WEN1_52 WEN1_53 WEN1_54
+  WEN1_55 WEN1_56 WEN1_57 WEN1_58 WEN1_59 WEN1_60 WEN1_61 WEN1_62 WEN1_63
+  WEN1_64 WEN1_65 WEN1_66 WEN1_67 WEN1_68 WEN1_69 WEN1_70 WEN1_71 WENY0_0
+  WENY0_1 WENY0_2 WENY0_3 WENY0_4 WENY0_5 WENY0_6 WENY0_7 WENY0_8 WENY0_9
+  WENY0_10 WENY0_11 WENY0_12 WENY0_13 WENY0_14 WENY0_15 WENY0_16 WENY0_17
+  WENY0_18 WENY0_19 WENY0_20 WENY0_21 WENY0_22 WENY0_23 WENY0_24 WENY0_25
+  WENY0_26 WENY0_27 WENY0_28 WENY0_29 WENY0_30 WENY0_31 WENY0_32 WENY0_33
+  WENY0_34 WENY0_35 WENY0_36 WENY0_37 WENY0_38 WENY0_39 WENY0_40 WENY0_41
+  WENY0_42 WENY0_43 WENY0_44 WENY0_45 WENY0_46 WENY0_47 WENY0_48 WENY0_49
+  WENY0_50 WENY0_51 WENY0_52 WENY0_53 WENY0_54 WENY0_55 WENY0_56 WENY0_57
+  WENY0_58 WENY0_59 WENY0_60 WENY0_61 WENY0_62 WENY0_63 WENY0_64 WENY0_65
+  WENY0_66 WENY0_67 WENY0_68 WENY0_69 WENY0_70 WENY0_71 WENY1_0 WENY1_1
+  WENY1_2 WENY1_3 WENY1_4 WENY1_5 WENY1_6 WENY1_7 WENY1_8 WENY1_9 WENY1_10
+  WENY1_11 WENY1_12 WENY1_13 WENY1_14 WENY1_15 WENY1_16 WENY1_17 WENY1_18
+  WENY1_19 WENY1_20 WENY1_21 WENY1_22 WENY1_23 WENY1_24 WENY1_25 WENY1_26
+  WENY1_27 WENY1_28 WENY1_29 WENY1_30 WENY1_31 WENY1_32 WENY1_33 WENY1_34
+  WENY1_35 WENY1_36 WENY1_37 WENY1_38 WENY1_39 WENY1_40 WENY1_41 WENY1_42
+  WENY1_43 WENY1_44 WENY1_45 WENY1_46 WENY1_47 WENY1_48 WENY1_49 WENY1_50
+  WENY1_51 WENY1_52 WENY1_53 WENY1_54 WENY1_55 WENY1_56 WENY1_57 WENY1_58
+  WENY1_59 WENY1_60 WENY1_61 WENY1_62 WENY1_63 WENY1_64 WENY1_65 WENY1_66
+  WENY1_67 WENY1_68 WENY1_69 WENY1_70 WENY1_71 sram464x144IO_SLICE
XMEMSLICE RA_P2[0] RA_P2[1] RA_P2[2] RA_P2[3] RA_P2[4] PSI BL[0]_0 BL[0]_1
+  BL[0]_2 BL[0]_3 BL[0]_4 BL[0]_5 BL[0]_6 BL[0]_7 BL[0]_8 BL[0]_9 BL[0]_10
+  BL[0]_11 BL[0]_12 BL[0]_13 BL[0]_14 BL[0]_15 BL[0]_16 BL[0]_17 BL[0]_18
+  BL[0]_19 BL[0]_20 BL[0]_21 BL[0]_22 BL[0]_23 BL[0]_24 BL[0]_25 BL[0]_26
+  BL[0]_27 BL[0]_28 BL[0]_29 BL[0]_30 BL[0]_31 BL[0]_32 BL[0]_33 BL[0]_34
+  BL[0]_35 BL[0]_36 BL[0]_37 BL[0]_38 BL[0]_39 BL[0]_40 BL[0]_41 BL[0]_42
+  BL[0]_43 BL[0]_44 BL[0]_45 BL[0]_46 BL[0]_47 BL[0]_48 BL[0]_49 BL[0]_50
+  BL[0]_51 BL[0]_52 BL[0]_53 BL[0]_54 BL[0]_55 BL[0]_56 BL[0]_57 BL[0]_58
+  BL[0]_59 BL[0]_60 BL[0]_61 BL[0]_62 BL[0]_63 BL[0]_64 BL[0]_65 BL[0]_66
+  BL[0]_67 BL[0]_68 BL[0]_69 BL[0]_70 BL[0]_71 BL[1]_0 BL[1]_1 BL[1]_2
+  BL[1]_3 BL[1]_4 BL[1]_5 BL[1]_6 BL[1]_7 BL[1]_8 BL[1]_9 BL[1]_10 BL[1]_11
+  BL[1]_12 BL[1]_13 BL[1]_14 BL[1]_15 BL[1]_16 BL[1]_17 BL[1]_18 BL[1]_19
+  BL[1]_20 BL[1]_21 BL[1]_22 BL[1]_23 BL[1]_24 BL[1]_25 BL[1]_26 BL[1]_27
+  BL[1]_28 BL[1]_29 BL[1]_30 BL[1]_31 BL[1]_32 BL[1]_33 BL[1]_34 BL[1]_35
+  BL[1]_36 BL[1]_37 BL[1]_38 BL[1]_39 BL[1]_40 BL[1]_41 BL[1]_42 BL[1]_43
+  BL[1]_44 BL[1]_45 BL[1]_46 BL[1]_47 BL[1]_48 BL[1]_49 BL[1]_50 BL[1]_51
+  BL[1]_52 BL[1]_53 BL[1]_54 BL[1]_55 BL[1]_56 BL[1]_57 BL[1]_58 BL[1]_59
+  BL[1]_60 BL[1]_61 BL[1]_62 BL[1]_63 BL[1]_64 BL[1]_65 BL[1]_66 BL[1]_67
+  BL[1]_68 BL[1]_69 BL[1]_70 BL[1]_71 BL[2]_0 BL[2]_1 BL[2]_2 BL[2]_3 BL[2]_4
+  BL[2]_5 BL[2]_6 BL[2]_7 BL[2]_8 BL[2]_9 BL[2]_10 BL[2]_11 BL[2]_12 BL[2]_13
+  BL[2]_14 BL[2]_15 BL[2]_16 BL[2]_17 BL[2]_18 BL[2]_19 BL[2]_20 BL[2]_21
+  BL[2]_22 BL[2]_23 BL[2]_24 BL[2]_25 BL[2]_26 BL[2]_27 BL[2]_28 BL[2]_29
+  BL[2]_30 BL[2]_31 BL[2]_32 BL[2]_33 BL[2]_34 BL[2]_35 BL[2]_36 BL[2]_37
+  BL[2]_38 BL[2]_39 BL[2]_40 BL[2]_41 BL[2]_42 BL[2]_43 BL[2]_44 BL[2]_45
+  BL[2]_46 BL[2]_47 BL[2]_48 BL[2]_49 BL[2]_50 BL[2]_51 BL[2]_52 BL[2]_53
+  BL[2]_54 BL[2]_55 BL[2]_56 BL[2]_57 BL[2]_58 BL[2]_59 BL[2]_60 BL[2]_61
+  BL[2]_62 BL[2]_63 BL[2]_64 BL[2]_65 BL[2]_66 BL[2]_67 BL[2]_68 BL[2]_69
+  BL[2]_70 BL[2]_71 BL[3]_0 BL[3]_1 BL[3]_2 BL[3]_3 BL[3]_4 BL[3]_5 BL[3]_6
+  BL[3]_7 BL[3]_8 BL[3]_9 BL[3]_10 BL[3]_11 BL[3]_12 BL[3]_13 BL[3]_14
+  BL[3]_15 BL[3]_16 BL[3]_17 BL[3]_18 BL[3]_19 BL[3]_20 BL[3]_21 BL[3]_22
+  BL[3]_23 BL[3]_24 BL[3]_25 BL[3]_26 BL[3]_27 BL[3]_28 BL[3]_29 BL[3]_30
+  BL[3]_31 BL[3]_32 BL[3]_33 BL[3]_34 BL[3]_35 BL[3]_36 BL[3]_37 BL[3]_38
+  BL[3]_39 BL[3]_40 BL[3]_41 BL[3]_42 BL[3]_43 BL[3]_44 BL[3]_45 BL[3]_46
+  BL[3]_47 BL[3]_48 BL[3]_49 BL[3]_50 BL[3]_51 BL[3]_52 BL[3]_53 BL[3]_54
+  BL[3]_55 BL[3]_56 BL[3]_57 BL[3]_58 BL[3]_59 BL[3]_60 BL[3]_61 BL[3]_62
+  BL[3]_63 BL[3]_64 BL[3]_65 BL[3]_66 BL[3]_67 BL[3]_68 BL[3]_69 BL[3]_70
+  BL[3]_71 DUM_ACTP DUM_RETNVT DUM_NACTC DBL DWL EMA0 EMA1 EMA2 GTP GTP
+  LA_P2[0] LA_P2[1] LA_P2[2] PSI LOG0_DWL LOG1 NACT_CC NBL[0]_0 NBL[0]_1
+  NBL[0]_2 NBL[0]_3 NBL[0]_4 NBL[0]_5 NBL[0]_6 NBL[0]_7 NBL[0]_8 NBL[0]_9
+  NBL[0]_10 NBL[0]_11 NBL[0]_12 NBL[0]_13 NBL[0]_14 NBL[0]_15 NBL[0]_16
+  NBL[0]_17 NBL[0]_18 NBL[0]_19 NBL[0]_20 NBL[0]_21 NBL[0]_22 NBL[0]_23
+  NBL[0]_24 NBL[0]_25 NBL[0]_26 NBL[0]_27 NBL[0]_28 NBL[0]_29 NBL[0]_30
+  NBL[0]_31 NBL[0]_32 NBL[0]_33 NBL[0]_34 NBL[0]_35 NBL[0]_36 NBL[0]_37
+  NBL[0]_38 NBL[0]_39 NBL[0]_40 NBL[0]_41 NBL[0]_42 NBL[0]_43 NBL[0]_44
+  NBL[0]_45 NBL[0]_46 NBL[0]_47 NBL[0]_48 NBL[0]_49 NBL[0]_50 NBL[0]_51
+  NBL[0]_52 NBL[0]_53 NBL[0]_54 NBL[0]_55 NBL[0]_56 NBL[0]_57 NBL[0]_58
+  NBL[0]_59 NBL[0]_60 NBL[0]_61 NBL[0]_62 NBL[0]_63 NBL[0]_64 NBL[0]_65
+  NBL[0]_66 NBL[0]_67 NBL[0]_68 NBL[0]_69 NBL[0]_70 NBL[0]_71 NBL[1]_0
+  NBL[1]_1 NBL[1]_2 NBL[1]_3 NBL[1]_4 NBL[1]_5 NBL[1]_6 NBL[1]_7 NBL[1]_8
+  NBL[1]_9 NBL[1]_10 NBL[1]_11 NBL[1]_12 NBL[1]_13 NBL[1]_14 NBL[1]_15
+  NBL[1]_16 NBL[1]_17 NBL[1]_18 NBL[1]_19 NBL[1]_20 NBL[1]_21 NBL[1]_22
+  NBL[1]_23 NBL[1]_24 NBL[1]_25 NBL[1]_26 NBL[1]_27 NBL[1]_28 NBL[1]_29
+  NBL[1]_30 NBL[1]_31 NBL[1]_32 NBL[1]_33 NBL[1]_34 NBL[1]_35 NBL[1]_36
+  NBL[1]_37 NBL[1]_38 NBL[1]_39 NBL[1]_40 NBL[1]_41 NBL[1]_42 NBL[1]_43
+  NBL[1]_44 NBL[1]_45 NBL[1]_46 NBL[1]_47 NBL[1]_48 NBL[1]_49 NBL[1]_50
+  NBL[1]_51 NBL[1]_52 NBL[1]_53 NBL[1]_54 NBL[1]_55 NBL[1]_56 NBL[1]_57
+  NBL[1]_58 NBL[1]_59 NBL[1]_60 NBL[1]_61 NBL[1]_62 NBL[1]_63 NBL[1]_64
+  NBL[1]_65 NBL[1]_66 NBL[1]_67 NBL[1]_68 NBL[1]_69 NBL[1]_70 NBL[1]_71
+  NBL[2]_0 NBL[2]_1 NBL[2]_2 NBL[2]_3 NBL[2]_4 NBL[2]_5 NBL[2]_6 NBL[2]_7
+  NBL[2]_8 NBL[2]_9 NBL[2]_10 NBL[2]_11 NBL[2]_12 NBL[2]_13 NBL[2]_14
+  NBL[2]_15 NBL[2]_16 NBL[2]_17 NBL[2]_18 NBL[2]_19 NBL[2]_20 NBL[2]_21
+  NBL[2]_22 NBL[2]_23 NBL[2]_24 NBL[2]_25 NBL[2]_26 NBL[2]_27 NBL[2]_28
+  NBL[2]_29 NBL[2]_30 NBL[2]_31 NBL[2]_32 NBL[2]_33 NBL[2]_34 NBL[2]_35
+  NBL[2]_36 NBL[2]_37 NBL[2]_38 NBL[2]_39 NBL[2]_40 NBL[2]_41 NBL[2]_42
+  NBL[2]_43 NBL[2]_44 NBL[2]_45 NBL[2]_46 NBL[2]_47 NBL[2]_48 NBL[2]_49
+  NBL[2]_50 NBL[2]_51 NBL[2]_52 NBL[2]_53 NBL[2]_54 NBL[2]_55 NBL[2]_56
+  NBL[2]_57 NBL[2]_58 NBL[2]_59 NBL[2]_60 NBL[2]_61 NBL[2]_62 NBL[2]_63
+  NBL[2]_64 NBL[2]_65 NBL[2]_66 NBL[2]_67 NBL[2]_68 NBL[2]_69 NBL[2]_70
+  NBL[2]_71 NBL[3]_0 NBL[3]_1 NBL[3]_2 NBL[3]_3 NBL[3]_4 NBL[3]_5 NBL[3]_6
+  NBL[3]_7 NBL[3]_8 NBL[3]_9 NBL[3]_10 NBL[3]_11 NBL[3]_12 NBL[3]_13
+  NBL[3]_14 NBL[3]_15 NBL[3]_16 NBL[3]_17 NBL[3]_18 NBL[3]_19 NBL[3]_20
+  NBL[3]_21 NBL[3]_22 NBL[3]_23 NBL[3]_24 NBL[3]_25 NBL[3]_26 NBL[3]_27
+  NBL[3]_28 NBL[3]_29 NBL[3]_30 NBL[3]_31 NBL[3]_32 NBL[3]_33 NBL[3]_34
+  NBL[3]_35 NBL[3]_36 NBL[3]_37 NBL[3]_38 NBL[3]_39 NBL[3]_40 NBL[3]_41
+  NBL[3]_42 NBL[3]_43 NBL[3]_44 NBL[3]_45 NBL[3]_46 NBL[3]_47 NBL[3]_48
+  NBL[3]_49 NBL[3]_50 NBL[3]_51 NBL[3]_52 NBL[3]_53 NBL[3]_54 NBL[3]_55
+  NBL[3]_56 NBL[3]_57 NBL[3]_58 NBL[3]_59 NBL[3]_60 NBL[3]_61 NBL[3]_62
+  NBL[3]_63 NBL[3]_64 NBL[3]_65 NBL[3]_66 NBL[3]_67 NBL[3]_68 NBL[3]_69
+  NBL[3]_70 NBL[3]_71 NGWE RET RET SAE_DUMMY VDDC_L VDDP VDDPE VDDPE VDDPE
+  VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE
+  VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE
+  VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE
+  VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE
+  VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE
+  VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE
+  VDDPE VDDPE VDDPE VPW sram464x144MEM_SLICE
.ENDS sram464x144TILE_TOP
****
.SUBCKT sram464x144 VDDCE VDDPE VSSE Q[143] Q[142] Q[141] Q[140] Q[139] Q[138]
+  Q[137] Q[136] Q[135] Q[134] Q[133] Q[132] Q[131] Q[130] Q[129] Q[128]
+  Q[127] Q[126] Q[125] Q[124] Q[123] Q[122] Q[121] Q[120] Q[119] Q[118]
+  Q[117] Q[116] Q[115] Q[114] Q[113] Q[112] Q[111] Q[110] Q[109] Q[108]
+  Q[107] Q[106] Q[105] Q[104] Q[103] Q[102] Q[101] Q[100] Q[99] Q[98] Q[97]
+  Q[96] Q[95] Q[94] Q[93] Q[92] Q[91] Q[90] Q[89] Q[88] Q[87] Q[86] Q[85]
+  Q[84] Q[83] Q[82] Q[81] Q[80] Q[79] Q[78] Q[77] Q[76] Q[75] Q[74] Q[73]
+  Q[72] Q[71] Q[70] Q[69] Q[68] Q[67] Q[66] Q[65] Q[64] Q[63] Q[62] Q[61]
+  Q[60] Q[59] Q[58] Q[57] Q[56] Q[55] Q[54] Q[53] Q[52] Q[51] Q[50] Q[49]
+  Q[48] Q[47] Q[46] Q[45] Q[44] Q[43] Q[42] Q[41] Q[40] Q[39] Q[38] Q[37]
+  Q[36] Q[35] Q[34] Q[33] Q[32] Q[31] Q[30] Q[29] Q[28] Q[27] Q[26] Q[25]
+  Q[24] Q[23] Q[22] Q[21] Q[20] Q[19] Q[18] Q[17] Q[16] Q[15] Q[14] Q[13]
+  Q[12] Q[11] Q[10] Q[9] Q[8] Q[7] Q[6] Q[5] Q[4] Q[3] Q[2] Q[1] Q[0] CLK CEN
+  WEN A[8] A[7] A[6] A[5] A[4] A[3] A[2] A[1] A[0] D[143] D[142] D[141]
+  D[140] D[139] D[138] D[137] D[136] D[135] D[134] D[133] D[132] D[131]
+  D[130] D[129] D[128] D[127] D[126] D[125] D[124] D[123] D[122] D[121]
+  D[120] D[119] D[118] D[117] D[116] D[115] D[114] D[113] D[112] D[111]
+  D[110] D[109] D[108] D[107] D[106] D[105] D[104] D[103] D[102] D[101]
+  D[100] D[99] D[98] D[97] D[96] D[95] D[94] D[93] D[92] D[91] D[90] D[89]
+  D[88] D[87] D[86] D[85] D[84] D[83] D[82] D[81] D[80] D[79] D[78] D[77]
+  D[76] D[75] D[74] D[73] D[72] D[71] D[70] D[69] D[68] D[67] D[66] D[65]
+  D[64] D[63] D[62] D[61] D[60] D[59] D[58] D[57] D[56] D[55] D[54] D[53]
+  D[52] D[51] D[50] D[49] D[48] D[47] D[46] D[45] D[44] D[43] D[42] D[41]
+  D[40] D[39] D[38] D[37] D[36] D[35] D[34] D[33] D[32] D[31] D[30] D[29]
+  D[28] D[27] D[26] D[25] D[24] D[23] D[22] D[21] D[20] D[19] D[18] D[17]
+  D[16] D[15] D[14] D[13] D[12] D[11] D[10] D[9] D[8] D[7] D[6] D[5] D[4]
+  D[3] D[2] D[1] D[0] EMA[2] EMA[1] EMA[0] EMAW[1] EMAW[0] RET1N
** sram464x144: 421912 flat devices **
XI0 A[0] CA1 CA2 CEN CLK D[1] D[3] D[5] D[7] D[9] D[11] D[13] D[15] D[17]
+  D[19] D[21] D[23] D[25] D[27] D[29] D[31] D[33] D[35] D[37] D[39] D[41]
+  D[43] D[45] D[47] D[49] D[51] D[53] D[55] D[57] D[59] D[61] D[63] D[65]
+  D[67] D[69] D[71] D[72] D[74] D[76] D[78] D[80] D[82] D[84] D[86] D[88]
+  D[90] D[92] D[94] D[96] D[98] D[100] D[102] D[104] D[106] D[108] D[110]
+  D[112] D[114] D[116] D[118] D[120] D[122] D[124] D[126] D[128] D[130]
+  D[132] D[134] D[136] D[138] D[140] D[142] D[0] D[2] D[4] D[6] D[8] D[10]
+  D[12] D[14] D[16] D[18] D[20] D[22] D[24] D[26] D[28] D[30] D[32] D[34]
+  D[36] D[38] D[40] D[42] D[44] D[46] D[48] D[50] D[52] D[54] D[56] D[58]
+  D[60] D[62] D[64] D[66] D[68] D[70] D[73] D[75] D[77] D[79] D[81] D[83]
+  D[85] D[87] D[89] D[91] D[93] D[95] D[97] D[99] D[101] D[103] D[105] D[107]
+  D[109] D[111] D[113] D[115] D[117] D[119] D[121] D[123] D[125] D[127]
+  D[129] D[131] D[133] D[135] D[137] D[139] D[141] D[143] EMA[0] EMA[1]
+  EMA[2] EMAW[0] EMAW[1] WEN A[1] A[2] LA2 PSI Q[1] Q[3] Q[5] Q[7] Q[9] Q[11]
+  Q[13] Q[15] Q[17] Q[19] Q[21] Q[23] Q[25] Q[27] Q[29] Q[31] Q[33] Q[35]
+  Q[37] Q[39] Q[41] Q[43] Q[45] Q[47] Q[49] Q[51] Q[53] Q[55] Q[57] Q[59]
+  Q[61] Q[63] Q[65] Q[67] Q[69] Q[71] Q[72] Q[74] Q[76] Q[78] Q[80] Q[82]
+  Q[84] Q[86] Q[88] Q[90] Q[92] Q[94] Q[96] Q[98] Q[100] Q[102] Q[104] Q[106]
+  Q[108] Q[110] Q[112] Q[114] Q[116] Q[118] Q[120] Q[122] Q[124] Q[126]
+  Q[128] Q[130] Q[132] Q[134] Q[136] Q[138] Q[140] Q[142] Q[0] Q[2] Q[4] Q[6]
+  Q[8] Q[10] Q[12] Q[14] Q[16] Q[18] Q[20] Q[22] Q[24] Q[26] Q[28] Q[30]
+  Q[32] Q[34] Q[36] Q[38] Q[40] Q[42] Q[44] Q[46] Q[48] Q[50] Q[52] Q[54]
+  Q[56] Q[58] Q[60] Q[62] Q[64] Q[66] Q[68] Q[70] Q[73] Q[75] Q[77] Q[79]
+  Q[81] Q[83] Q[85] Q[87] Q[89] Q[91] Q[93] Q[95] Q[97] Q[99] Q[101] Q[103]
+  Q[105] Q[107] Q[109] Q[111] Q[113] Q[115] Q[117] Q[119] Q[121] Q[123]
+  Q[125] Q[127] Q[129] Q[131] Q[133] Q[135] Q[137] Q[139] Q[141] Q[143] A[4]
+  A[5] A[6] A[7] A[8] A[3] RET1N VDDCE VDDPE VSSE WEN0_0 WEN0_1 WEN0_2 WEN0_3
+  WEN0_4 WEN0_5 WEN0_6 WEN0_7 WEN0_8 WEN0_9 WEN0_10 WEN0_11 WEN0_12 WEN0_13
+  WEN0_14 WEN0_15 WEN0_16 WEN0_17 WEN0_18 WEN0_19 WEN0_20 WEN0_21 WEN0_22
+  WEN0_23 WEN0_24 WEN0_25 WEN0_26 WEN0_27 WEN0_28 WEN0_29 WEN0_30 WEN0_31
+  WEN0_32 WEN0_33 WEN0_34 WEN0_35 WEN0_36 WEN0_37 WEN0_38 WEN0_39 WEN0_40
+  WEN0_41 WEN0_42 WEN0_43 WEN0_44 WEN0_45 WEN0_46 WEN0_47 WEN0_48 WEN0_49
+  WEN0_50 WEN0_51 WEN0_52 WEN0_53 WEN0_54 WEN0_55 WEN0_56 WEN0_57 WEN0_58
+  WEN0_59 WEN0_60 WEN0_61 WEN0_62 WEN0_63 WEN0_64 WEN0_65 WEN0_66 WEN0_67
+  WEN0_68 WEN0_69 WEN0_70 WEN0_71 WEN1_0 WEN1_1 WEN1_2 WEN1_3 WEN1_4 WEN1_5
+  WEN1_6 WEN1_7 WEN1_8 WEN1_9 WEN1_10 WEN1_11 WEN1_12 WEN1_13 WEN1_14 WEN1_15
+  WEN1_16 WEN1_17 WEN1_18 WEN1_19 WEN1_20 WEN1_21 WEN1_22 WEN1_23 WEN1_24
+  WEN1_25 WEN1_26 WEN1_27 WEN1_28 WEN1_29 WEN1_30 WEN1_31 WEN1_32 WEN1_33
+  WEN1_34 WEN1_35 WEN1_36 WEN1_37 WEN1_38 WEN1_39 WEN1_40 WEN1_41 WEN1_42
+  WEN1_43 WEN1_44 WEN1_45 WEN1_46 WEN1_47 WEN1_48 WEN1_49 WEN1_50 WEN1_51
+  WEN1_52 WEN1_53 WEN1_54 WEN1_55 WEN1_56 WEN1_57 WEN1_58 WEN1_59 WEN1_60
+  WEN1_61 WEN1_62 WEN1_63 WEN1_64 WEN1_65 WEN1_66 WEN1_67 WEN1_68 WEN1_69
+  WEN1_70 WEN1_71 WENY0_0 WENY0_1 WENY0_2 WENY0_3 WENY0_4 WENY0_5 WENY0_6
+  WENY0_7 WENY0_8 WENY0_9 WENY0_10 WENY0_11 WENY0_12 WENY0_13 WENY0_14
+  WENY0_15 WENY0_16 WENY0_17 WENY0_18 WENY0_19 WENY0_20 WENY0_21 WENY0_22
+  WENY0_23 WENY0_24 WENY0_25 WENY0_26 WENY0_27 WENY0_28 WENY0_29 WENY0_30
+  WENY0_31 WENY0_32 WENY0_33 WENY0_34 WENY0_35 WENY0_36 WENY0_37 WENY0_38
+  WENY0_39 WENY0_40 WENY0_41 WENY0_42 WENY0_43 WENY0_44 WENY0_45 WENY0_46
+  WENY0_47 WENY0_48 WENY0_49 WENY0_50 WENY0_51 WENY0_52 WENY0_53 WENY0_54
+  WENY0_55 WENY0_56 WENY0_57 WENY0_58 WENY0_59 WENY0_60 WENY0_61 WENY0_62
+  WENY0_63 WENY0_64 WENY0_65 WENY0_66 WENY0_67 WENY0_68 WENY0_69 WENY0_70
+  WENY0_71 WENY1_0 WENY1_1 WENY1_2 WENY1_3 WENY1_4 WENY1_5 WENY1_6 WENY1_7
+  WENY1_8 WENY1_9 WENY1_10 WENY1_11 WENY1_12 WENY1_13 WENY1_14 WENY1_15
+  WENY1_16 WENY1_17 WENY1_18 WENY1_19 WENY1_20 WENY1_21 WENY1_22 WENY1_23
+  WENY1_24 WENY1_25 WENY1_26 WENY1_27 WENY1_28 WENY1_29 WENY1_30 WENY1_31
+  WENY1_32 WENY1_33 WENY1_34 WENY1_35 WENY1_36 WENY1_37 WENY1_38 WENY1_39
+  WENY1_40 WENY1_41 WENY1_42 WENY1_43 WENY1_44 WENY1_45 WENY1_46 WENY1_47
+  WENY1_48 WENY1_49 WENY1_50 WENY1_51 WENY1_52 WENY1_53 WENY1_54 WENY1_55
+  WENY1_56 WENY1_57 WENY1_58 WENY1_59 WENY1_60 WENY1_61 WENY1_62 WENY1_63
+  WENY1_64 WENY1_65 WENY1_66 WENY1_67 WENY1_68 WENY1_69 WENY1_70 WENY1_71
+  sram464x144TILE_TOP
.ENDS sram464x144
